$ Spice netlist generated by v2lvs
$ v2013.4_37.29    Fri Jan 31 15:23:28 PST 2014
.INCLUDE "/tools2/courses/ee6321/share/ibm13rflpvt/lvs_netlist/ibm13rflpvt.cdl"

.SUBCKT incomingPortHandler_0 clk reset localRouterAddress[3]
+ localRouterAddress[2] localRouterAddress[1] localRouterAddress[0]
+ destinationAddressIn[11] destinationAddressIn[10] destinationAddressIn[9]
+ destinationAddressIn[8] destinationAddressIn[7] destinationAddressIn[6]
+ destinationAddressIn[5] destinationAddressIn[4] destinationAddressIn[3]
+ destinationAddressIn[2] destinationAddressIn[1] destinationAddressIn[0]
+ requesterAddressIn[3] requesterAddressIn[2] requesterAddressIn[1]
+ requesterAddressIn[0] readIn writeIn outputPortSelect[3] outputPortSelect[2]
+ outputPortSelect[1] outputPortSelect[0] memRead memWrite
XmemWrite_reg memWrite clk n22 DFFHQX1TS
XmemRead_reg memRead clk n27 DFFHQX1TS
XoutputPortSelect_reg[3] outputPortSelect[3] clk n26 DFFHQX1TS
XoutputPortSelect_reg[2] outputPortSelect[2] clk n25 DFFHQX1TS
XoutputPortSelect_reg[1] outputPortSelect[1] clk n24 DFFHQX1TS
XoutputPortSelect_reg[0] outputPortSelect[0] clk n23 DFFHQX1TS
XU3 n22 n17 writeIn n16 memWrite AO22XLTS
XU4 n5 localRouterAddress[3] destinationAddressIn[11] NAND2BXLTS
XU5 n3 localRouterAddress[2] destinationAddressIn[10] NOR2BX1TS
XU6 n2 localRouterAddress[3] destinationAddressIn[11] NOR2BX1TS
XU7 n1 n5 n3 n2 AOI21X1TS
XU8 n14 readIn writeIn reset AOI2BB1XLTS
XU9 n11 n14 INVX2TS
XU10 n23 n1 n11 NOR2XLTS
XU11 n4 localRouterAddress[2] destinationAddressIn[10] NAND2BXLTS
XU12 n24 n11 n2 n4 n5 n11 OAI32X1TS
XU13 n6 destinationAddressIn[9] INVX2TS
XU14 n7 destinationAddressIn[8] INVX2TS
XU15 n10 localRouterAddress[1] n6 localRouterAddress[0] n7 AOI22X1TS
XU16 n15 n5 n4 n3 n2 NOR4BBXLTS
XU17 n9 localRouterAddress[1] n6 OR2X1TS
XU18 n8 localRouterAddress[0] n7 OR2X1TS
XU19 n13 n10 n15 n9 n8 NAND4XLTS
XU20 n17 reset n13 NOR2XLTS
XU21 n16 reset readIn writeIn NOR3XLTS
XU22 n27 readIn n17 memRead n16 AO22XLTS
XU23 n12 n10 n9 NAND2BXLTS
XU24 n26 n15 n11 n12 NOR3BXLTS
XU25 n25 n15 n14 n13 n12 AND4X1TS
.ENDS

.SUBCKT cacheAccessArbiter clk reset cacheAddressIn_NORTH[7]
+ cacheAddressIn_NORTH[6] cacheAddressIn_NORTH[5] cacheAddressIn_NORTH[4]
+ cacheAddressIn_NORTH[3] cacheAddressIn_NORTH[2] cacheAddressIn_NORTH[1]
+ cacheAddressIn_NORTH[0] requesterAddressIn_NORTH[3]
+ requesterAddressIn_NORTH[2] requesterAddressIn_NORTH[1]
+ requesterAddressIn_NORTH[0] memRead_NORTH memWrite_NORTH dataIn_NORTH[5]
+ dataIn_NORTH[4] dataIn_NORTH[3] dataIn_NORTH[2] dataIn_NORTH[1]
+ dataIn_NORTH[0] readReady_NORTH requesterAddressOut_NORTH[3]
+ requesterAddressOut_NORTH[2] requesterAddressOut_NORTH[1]
+ requesterAddressOut_NORTH[0] cacheDataOut_NORTH[5] cacheDataOut_NORTH[4]
+ cacheDataOut_NORTH[3] cacheDataOut_NORTH[2] cacheDataOut_NORTH[1]
+ cacheDataOut_NORTH[0] cacheAddressIn_SOUTH[7] cacheAddressIn_SOUTH[6]
+ cacheAddressIn_SOUTH[5] cacheAddressIn_SOUTH[4] cacheAddressIn_SOUTH[3]
+ cacheAddressIn_SOUTH[2] cacheAddressIn_SOUTH[1] cacheAddressIn_SOUTH[0]
+ requesterAddressIn_SOUTH[3] requesterAddressIn_SOUTH[2]
+ requesterAddressIn_SOUTH[1] requesterAddressIn_SOUTH[0] memRead_SOUTH
+ memWrite_SOUTH dataIn_SOUTH[5] dataIn_SOUTH[4] dataIn_SOUTH[3]
+ dataIn_SOUTH[2] dataIn_SOUTH[1] dataIn_SOUTH[0] readReady_SOUTH
+ requesterAddressOut_SOUTH[3] requesterAddressOut_SOUTH[2]
+ requesterAddressOut_SOUTH[1] requesterAddressOut_SOUTH[0]
+ cacheDataOut_SOUTH[5] cacheDataOut_SOUTH[4] cacheDataOut_SOUTH[3]
+ cacheDataOut_SOUTH[2] cacheDataOut_SOUTH[1] cacheDataOut_SOUTH[0]
+ cacheAddressIn_EAST[7] cacheAddressIn_EAST[6] cacheAddressIn_EAST[5]
+ cacheAddressIn_EAST[4] cacheAddressIn_EAST[3] cacheAddressIn_EAST[2]
+ cacheAddressIn_EAST[1] cacheAddressIn_EAST[0] requesterAddressIn_EAST[3]
+ requesterAddressIn_EAST[2] requesterAddressIn_EAST[1]
+ requesterAddressIn_EAST[0] memRead_EAST memWrite_EAST dataIn_EAST[5]
+ dataIn_EAST[4] dataIn_EAST[3] dataIn_EAST[2] dataIn_EAST[1] dataIn_EAST[0]
+ readReady_EAST requesterAddressOut_EAST[3] requesterAddressOut_EAST[2]
+ requesterAddressOut_EAST[1] requesterAddressOut_EAST[0] cacheDataOut_EAST[5]
+ cacheDataOut_EAST[4] cacheDataOut_EAST[3] cacheDataOut_EAST[2]
+ cacheDataOut_EAST[1] cacheDataOut_EAST[0] cacheAddressIn_WEST[7]
+ cacheAddressIn_WEST[6] cacheAddressIn_WEST[5] cacheAddressIn_WEST[4]
+ cacheAddressIn_WEST[3] cacheAddressIn_WEST[2] cacheAddressIn_WEST[1]
+ cacheAddressIn_WEST[0] requesterAddressIn_WEST[3] requesterAddressIn_WEST[2]
+ requesterAddressIn_WEST[1] requesterAddressIn_WEST[0] memRead_WEST
+ memWrite_WEST dataIn_WEST[5] dataIn_WEST[4] dataIn_WEST[3] dataIn_WEST[2]
+ dataIn_WEST[1] dataIn_WEST[0] readReady_WEST requesterAddressOut_WEST[3]
+ requesterAddressOut_WEST[2] requesterAddressOut_WEST[1]
+ requesterAddressOut_WEST[0] cacheDataOut_WEST[5] cacheDataOut_WEST[4]
+ cacheDataOut_WEST[3] cacheDataOut_WEST[2] cacheDataOut_WEST[1]
+ cacheDataOut_WEST[0] cacheDataIn_A[5] cacheDataIn_A[4] cacheDataIn_A[3]
+ cacheDataIn_A[2] cacheDataIn_A[1] cacheDataIn_A[0] cacheAddressIn_A[7]
+ cacheAddressIn_A[6] cacheAddressIn_A[5] cacheAddressIn_A[4]
+ cacheAddressIn_A[3] cacheAddressIn_A[2] cacheAddressIn_A[1]
+ cacheAddressIn_A[0] cacheDataOut_A[5] cacheDataOut_A[4] cacheDataOut_A[3]
+ cacheDataOut_A[2] cacheDataOut_A[1] cacheDataOut_A[0] memWrite_A
+ cacheDataIn_B[5] cacheDataIn_B[4] cacheDataIn_B[3] cacheDataIn_B[2]
+ cacheDataIn_B[1] cacheDataIn_B[0] cacheAddressIn_B[7] cacheAddressIn_B[6]
+ cacheAddressIn_B[5] cacheAddressIn_B[4] cacheAddressIn_B[3]
+ cacheAddressIn_B[2] cacheAddressIn_B[1] cacheAddressIn_B[0] cacheDataOut_B[5]
+ cacheDataOut_B[4] cacheDataOut_B[3] cacheDataOut_B[2] cacheDataOut_B[1]
+ cacheDataOut_B[0] memWrite_B
XFE_PHC266_N5383 FE_PHN266_N5383 FE_PHN232_N5383 CLKBUFX2TS
XFE_PHC265_N5391 FE_PHN265_N5391 N5391 CLKBUFX2TS
XFE_PHC243_N5389 FE_PHN243_N5389 N5389 DLY1X1TS
XFE_PHC242_N5392 FE_PHN242_N5392 N5392 DLY1X1TS
XFE_PHC241_N5391 FE_PHN241_N5391 FE_PHN265_N5391 DLY1X1TS
XFE_PHC240_N5390 FE_PHN240_N5390 N5390 DLY1X1TS
XFE_PHC239_N5393 FE_PHN239_N5393 N5393 DLY1X1TS
XFE_PHC238_N5394 FE_PHN238_N5394 N5394 DLY1X1TS
XFE_PHC237_N5385 FE_PHN237_N5385 N5385 DLY2X1TS
XFE_PHC236_N5384 N5384 FE_PHN236_N5384 DLY2X1TS
XFE_PHC235_N5382 FE_PHN235_N5382 N5382 DLY2X1TS
XFE_PHC234_N5386 FE_PHN234_N5386 N5386 DLY2X1TS
XFE_PHC233_N5381 N5381 FE_PHN233_N5381 DLY2X1TS
XFE_PHC232_N5383 FE_PHN232_N5383 N5383 DLY2X1TS
XFE_PHC230_N5377 FE_PHN230_N5377 N5377 DLY3X1TS
XFE_PHC229_N5378 N5378 FE_PHN229_N5378 DLY3X1TS
XFE_PHC228_N5374 N5374 FE_PHN228_N5374 DLY3X4TS
XFE_PHC227_N5376 FE_PHN227_N5376 N5376 DLY3X4TS
XFE_PHC226_N5375 FE_PHN226_N5375 N5375 DLY3X4TS
XFE_PHC225_N5373 FE_PHN225_N5373 N5373 DLY4X1TS
XFE_PHC224_N5399 FE_PHN224_N5399 N5399 DLY4X4TS
XFE_PHC223_N5401 FE_PHN223_N5401 N5401 DLY4X4TS
XFE_PHC222_N5398 N5398 FE_PHN222_N5398 DLY4X1TS
XFE_PHC221_N5402 N5402 FE_PHN221_N5402 DLY4X1TS
XFE_PHC220_N5397 FE_PHN220_N5397 N5397 DLY4X1TS
XFE_PHC219_N5400 N5400 FE_PHN219_N5400 DLY4X1TS
XFE_DBTC188_n3 FE_DBTN188_n3 n3 INVX2TS
XFE_DBTC187_n13 FE_DBTN187_n13 n13 INVX2TS
XFE_DBTC186_n15 FE_DBTN186_n15 n15 INVX2TS
XFE_DBTC185_n16 FE_DBTN185_n16 n16 INVX2TS
XFE_DBTC184_n18 FE_DBTN184_n18 n18 INVX2TS
XFE_DBTC183_n26 FE_DBTN183_n26 n26 INVX2TS
XFE_DBTC182_n35 FE_DBTN182_n35 n35 INVX2TS
XFE_DBTC181_n57 FE_DBTN181_n57 n57 INVX2TS
XFE_DBTC180_n67 FE_DBTN180_n67 n67 INVX2TS
XFE_DBTC179_n93 FE_DBTN179_n93 n93 INVX2TS
XFE_DBTC178_n98 FE_DBTN178_n98 n98 INVX2TS
XFE_DBTC177_n146 FE_DBTN177_n146 n146 INVX2TS
XFE_DBTC176_n498 FE_DBTN176_n498 n498 INVX2TS
XFE_DBTC175_n681 FE_DBTN175_n681 n681 INVX2TS
XFE_DBTC174_n205 FE_DBTN174_n205 n205 INVX2TS
XFE_DBTC173_n254 FE_DBTN173_n254 n254 INVX2TS
XFE_DBTC172_n367 FE_DBTN172_n367 n367 INVX2TS
XFE_DBTC171_n550 FE_DBTN171_n550 n550 INVX2TS
XFE_DBTC170_n612 FE_DBTN170_n612 n612 INVX2TS
XFE_DBTC169_n651 FE_DBTN169_n651 n651 INVX2TS
XFE_DBTC168_n683 FE_DBTN168_n683 n683 INVX2TS
XFE_DBTC167_n702 FE_DBTN167_n702 n702 INVX2TS
XreadReady_Concatenated_reg[3] readReady_WEST 1000 clk N5340 n793 EDFFX1TS
XreadReady_Concatenated_reg[2] readReady_EAST 1001 clk N5332 n793 EDFFX1TS
XreadReady_Concatenated_reg[1] readReady_SOUTH 1002 clk N5324 n793 EDFFX1TS
XreadReady_Concatenated_reg[0] readReady_NORTH 1003 clk N5316 n793 EDFFX1TS
XrequesterPortBuffer_reg[4][1] 1004 n831 clk n1274 VDD VDD DFFNSRX1TS
XrequesterAddressBuffer_reg[1][3] requesterAddressBuffer[1][3] 1005 clk n1347
+ VDD VDD DFFNSRX1TS
XrequesterAddressBuffer_reg[1][2] requesterAddressBuffer[1][2] 1006 clk n1348
+ VDD VDD DFFNSRX1TS
XrequesterAddressBuffer_reg[1][1] requesterAddressBuffer[1][1] 1007 clk n1349
+ VDD VDD DFFNSRX1TS
XrequesterAddressBuffer_reg[1][0] requesterAddressBuffer[1][0] 1008 clk n1350
+ VDD VDD DFFNSRX1TS
XdataToWriteBuffer_reg[0][5] dataToWriteBuffer[0][5] 1009 clk n1262 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[0][4] dataToWriteBuffer[0][4] 1010 clk n1263 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[0][3] dataToWriteBuffer[0][3] 1011 clk n1264 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[0][2] dataToWriteBuffer[0][2] 1012 clk n1265 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[0][1] dataToWriteBuffer[0][1] 1013 clk n1266 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[0][0] dataToWriteBuffer[0][0] 1014 clk n1267 VDD VDD
+ DFFNSRX1TS
XaddressToWriteBuffer_reg[0][7] addressToWriteBuffer[0][7] 1015 clk n1339 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[0][6] addressToWriteBuffer[0][6] 1016 clk n1340 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[0][5] addressToWriteBuffer[0][5] 1017 clk n1341 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[0][4] addressToWriteBuffer[0][4] 1018 clk n1342 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[0][3] addressToWriteBuffer[0][3] 1019 clk n1343 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[0][2] addressToWriteBuffer[0][2] 1020 clk n1344 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[0][1] addressToWriteBuffer[0][1] 1021 clk n1345 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[0][0] addressToWriteBuffer[0][0] 1022 clk n1346 VDD
+ VDD DFFNSRX1TS
XrequesterPortBuffer_reg[0][1] requesterPortBuffer[0][1] 1023 clk n1282 VDD VDD
+ DFFNSRX1TS
XrequesterPortBuffer_reg[0][0] requesterPortBuffer[0][0] 1024 clk n1363 VDD VDD
+ DFFNSRX1TS
XrequesterAddressBuffer_reg[0][3] requesterAddressBuffer[0][3] 1025 clk n1351
+ VDD VDD DFFNSRX1TS
XrequesterAddressBuffer_reg[0][2] requesterAddressBuffer[0][2] 1026 clk n1352
+ VDD VDD DFFNSRX1TS
XrequesterAddressBuffer_reg[0][1] requesterAddressBuffer[0][1] 1027 clk n1353
+ VDD VDD DFFNSRX1TS
XrequesterAddressBuffer_reg[0][0] requesterAddressBuffer[0][0] 1028 clk n1354
+ VDD VDD DFFNSRX1TS
XrequesterPortBuffer_reg[1][1] requesterPortBuffer[1][1] 1029 clk n1280 VDD VDD
+ DFFNSRX1TS
XrequesterPortBuffer_reg[1][0] requesterPortBuffer[1][0] 1030 clk n1281 VDD VDD
+ DFFNSRX1TS
XisWrite_reg[3] isWrite[3] 1031 clk n1216 VDD VDD DFFNSRX1TS
XrequesterPortBuffer_reg[4][0] requesterPortBuffer[4][0] 1032 clk n825 VDD VDD
+ DFFNSRX1TS
XisWrite_reg[4] isWrite[4] 1033 clk n1215 VDD VDD DFFNSRX1TS
XdataToWriteBuffer_reg[4][5] dataToWriteBuffer[4][5] 1034 clk n1238 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[4][4] dataToWriteBuffer[4][4] 1035 clk n1239 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[4][3] dataToWriteBuffer[4][3] 1036 clk n1240 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[4][2] dataToWriteBuffer[4][2] 1037 clk n1241 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[4][1] dataToWriteBuffer[4][1] 1038 clk n1242 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[4][0] dataToWriteBuffer[4][0] 1039 clk n1243 VDD VDD
+ DFFNSRX1TS
XaddressToWriteBuffer_reg[4][7] addressToWriteBuffer[4][7] 1040 clk n1307 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[4][6] addressToWriteBuffer[4][6] 1041 clk n1308 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[4][5] addressToWriteBuffer[4][5] 1042 clk n1309 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[4][4] addressToWriteBuffer[4][4] 1043 clk n1310 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[4][3] addressToWriteBuffer[4][3] 1044 clk n1311 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[4][2] addressToWriteBuffer[4][2] 1045 clk n1312 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[4][1] addressToWriteBuffer[4][1] 1046 clk n1313 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[4][0] addressToWriteBuffer[4][0] 1047 clk n1314 VDD
+ VDD DFFNSRX1TS
XisWrite_reg[2] isWrite[2] 1048 clk n1217 VDD VDD DFFNSRX1TS
XdataToWriteBuffer_reg[1][5] dataToWriteBuffer[1][5] 1049 clk n1256 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[1][4] dataToWriteBuffer[1][4] 1050 clk n1257 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[1][3] dataToWriteBuffer[1][3] 1051 clk n1258 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[1][2] dataToWriteBuffer[1][2] 1052 clk n1259 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[1][1] dataToWriteBuffer[1][1] 1053 clk n1260 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[1][0] dataToWriteBuffer[1][0] 1054 clk n1261 VDD VDD
+ DFFNSRX1TS
XaddressToWriteBuffer_reg[1][7] addressToWriteBuffer[1][7] 1055 clk n1331 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[1][6] addressToWriteBuffer[1][6] 1056 clk n1332 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[1][5] addressToWriteBuffer[1][5] 1057 clk n1333 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[1][4] addressToWriteBuffer[1][4] 1058 clk n1334 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[1][3] addressToWriteBuffer[1][3] 1059 clk n1335 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[1][2] addressToWriteBuffer[1][2] 1060 clk n1336 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[1][1] addressToWriteBuffer[1][1] 1061 clk n1337 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[1][0] addressToWriteBuffer[1][0] 1062 clk n1338 VDD
+ VDD DFFNSRX1TS
XrequesterPortBuffer_reg[3][0] requesterPortBuffer[3][0] 1063 clk n1277 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[3][5] dataToWriteBuffer[3][5] 1064 clk n1244 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[3][4] dataToWriteBuffer[3][4] 1065 clk n1245 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[3][3] dataToWriteBuffer[3][3] 1066 clk n1246 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[3][2] dataToWriteBuffer[3][2] 1067 clk n1247 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[3][1] dataToWriteBuffer[3][1] 1068 clk n1248 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[3][0] dataToWriteBuffer[3][0] 1069 clk n1249 VDD VDD
+ DFFNSRX1TS
XaddressToWriteBuffer_reg[3][7] addressToWriteBuffer[3][7] 1070 clk n1315 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[3][6] addressToWriteBuffer[3][6] 1071 clk n1316 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[3][5] addressToWriteBuffer[3][5] 1072 clk n1317 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[3][4] addressToWriteBuffer[3][4] 1073 clk n1318 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[3][3] addressToWriteBuffer[3][3] 1074 clk n1319 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[3][2] addressToWriteBuffer[3][2] 1075 clk n1320 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[3][1] addressToWriteBuffer[3][1] 1076 clk n1321 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[3][0] addressToWriteBuffer[3][0] 1077 clk n1322 VDD
+ VDD DFFNSRX1TS
XdataToWriteBuffer_reg[5][5] dataToWriteBuffer[5][5] 1078 clk n1232 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[5][4] dataToWriteBuffer[5][4] 1079 clk n1233 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[5][3] dataToWriteBuffer[5][3] 1080 clk n1234 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[5][2] dataToWriteBuffer[5][2] 1081 clk n1235 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[5][1] dataToWriteBuffer[5][1] 1082 clk n1236 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[5][0] dataToWriteBuffer[5][0] 1083 clk n1237 VDD VDD
+ DFFNSRX1TS
XaddressToWriteBuffer_reg[5][7] addressToWriteBuffer[5][7] 1084 clk n1299 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[5][6] addressToWriteBuffer[5][6] 1085 clk n1300 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[5][5] addressToWriteBuffer[5][5] 1086 clk n1301 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[5][4] addressToWriteBuffer[5][4] 1087 clk n1302 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[5][3] addressToWriteBuffer[5][3] 1088 clk n1303 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[5][2] addressToWriteBuffer[5][2] 1089 clk n1304 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[5][1] addressToWriteBuffer[5][1] 1090 clk n1305 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[5][0] addressToWriteBuffer[5][0] 1091 clk n1306 VDD
+ VDD DFFNSRX1TS
XrequesterPortBuffer_reg[2][0] requesterPortBuffer[2][0] 1092 clk n1279 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[2][5] dataToWriteBuffer[2][5] 1093 clk n1250 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[2][4] dataToWriteBuffer[2][4] 1094 clk n1251 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[2][3] dataToWriteBuffer[2][3] 1095 clk n1252 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[2][2] dataToWriteBuffer[2][2] 1096 clk n1253 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[2][1] dataToWriteBuffer[2][1] 1097 clk n1254 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[2][0] dataToWriteBuffer[2][0] 1098 clk n1255 VDD VDD
+ DFFNSRX1TS
XaddressToWriteBuffer_reg[2][7] addressToWriteBuffer[2][7] 1099 clk n1323 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[2][6] addressToWriteBuffer[2][6] 1100 clk n1324 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[2][5] addressToWriteBuffer[2][5] 1101 clk n1325 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[2][4] addressToWriteBuffer[2][4] 1102 clk n1326 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[2][3] addressToWriteBuffer[2][3] 1103 clk n1327 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[2][2] addressToWriteBuffer[2][2] 1104 clk n1328 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[2][1] addressToWriteBuffer[2][1] 1105 clk n1329 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[2][0] addressToWriteBuffer[2][0] 1106 clk n1330 VDD
+ VDD DFFNSRX1TS
XrequesterPortBuffer_reg[2][1] requesterPortBuffer[2][1] 1107 clk n1278 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[6][5] dataToWriteBuffer[6][5] 1108 clk n1226 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[6][4] dataToWriteBuffer[6][4] 1109 clk n1227 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[6][3] dataToWriteBuffer[6][3] 1110 clk n1228 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[6][2] dataToWriteBuffer[6][2] 1111 clk n1229 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[6][1] dataToWriteBuffer[6][1] 1112 clk n1230 VDD VDD
+ DFFNSRX1TS
XdataToWriteBuffer_reg[6][0] dataToWriteBuffer[6][0] 1113 clk n1231 VDD VDD
+ DFFNSRX1TS
XaddressToWriteBuffer_reg[6][7] addressToWriteBuffer[6][7] 1114 clk n1291 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[6][6] addressToWriteBuffer[6][6] 1115 clk n1292 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[6][5] addressToWriteBuffer[6][5] 1116 clk n1293 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[6][4] addressToWriteBuffer[6][4] 1117 clk n1294 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[6][3] addressToWriteBuffer[6][3] 1118 clk n1295 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[6][2] addressToWriteBuffer[6][2] 1119 clk n1296 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[6][1] addressToWriteBuffer[6][1] 1120 clk n1297 VDD
+ VDD DFFNSRX1TS
XaddressToWriteBuffer_reg[6][0] addressToWriteBuffer[6][0] 1121 clk n1298 VDD
+ VDD DFFNSRX1TS
XrequesterPortBuffer_reg[3][1] requesterPortBuffer[3][1] 1122 clk n1276 VDD VDD
+ DFFNSRX1TS
XrequesterPortBuffer_reg[5][0] requesterPortBuffer[5][0] 1123 clk n1273 VDD VDD
+ DFFNSRX1TS
XrequesterPortBuffer_reg[5][1] requesterPortBuffer[5][1] 1124 clk n1272 VDD VDD
+ DFFNSRX1TS
XisWrite_reg[0] isWrite[0] 1125 clk n1219 VDD VDD DFFNSRX1TS
XnextEmptyBuffer_reg[1] N742 n12 clk n1210 VDD VDD DFFNSRX1TS
XnextEmptyBuffer_reg[0] N741 1126 clk n1211 VDD VDD DFFNSRX1TS
XprevMemRead_B_reg prevMemRead_B 1127 clk n1204 VDD VDD DFFNSRX1TS
XprevMemRead_A_reg prevMemRead_A 1128 clk n1203 VDD VDD DFFNSRX1TS
XprevRequesterAddress_A_reg[3] prevRequesterAddress_A[3] n8 clk n1205 VDD VDD
+ DFFNSRX1TS
XprevRequesterAddress_A_reg[2] prevRequesterAddress_A[2] n9 clk n1206 VDD VDD
+ DFFNSRX1TS
XprevRequesterAddress_A_reg[1] prevRequesterAddress_A[1] n10 clk n1207 VDD VDD
+ DFFNSRX1TS
XprevRequesterAddress_A_reg[0] prevRequesterAddress_A[0] n11 clk n1208 VDD VDD
+ DFFNSRX1TS
XdataOut_Concatenated_reg[3][5] cacheDataOut_WEST[5] 1129 N5402 clk TLATXLTS
XdataOut_Concatenated_reg[3][4] cacheDataOut_WEST[4] 1130 FE_PHN223_N5401 clk
+ TLATXLTS
XdataOut_Concatenated_reg[3][3] cacheDataOut_WEST[3] 1131 N5400 clk TLATXLTS
XdataOut_Concatenated_reg[3][2] cacheDataOut_WEST[2] 1132 FE_PHN224_N5399 clk
+ TLATXLTS
XdataOut_Concatenated_reg[3][1] cacheDataOut_WEST[1] 1133 N5398 clk TLATXLTS
XdataOut_Concatenated_reg[3][0] cacheDataOut_WEST[0] 1134 FE_PHN220_N5397 clk
+ TLATXLTS
XdataOut_Concatenated_reg[2][5] cacheDataOut_EAST[5] 1135 FE_PHN238_N5394 clk
+ TLATXLTS
XdataOut_Concatenated_reg[2][4] cacheDataOut_EAST[4] 1136 FE_PHN239_N5393 clk
+ TLATXLTS
XdataOut_Concatenated_reg[2][3] cacheDataOut_EAST[3] 1137 FE_PHN242_N5392 clk
+ TLATXLTS
XdataOut_Concatenated_reg[2][2] cacheDataOut_EAST[2] 1138 FE_PHN241_N5391 clk
+ TLATXLTS
XdataOut_Concatenated_reg[2][1] cacheDataOut_EAST[1] 1139 FE_PHN240_N5390 clk
+ TLATXLTS
XdataOut_Concatenated_reg[2][0] cacheDataOut_EAST[0] 1140 FE_PHN243_N5389 clk
+ TLATXLTS
XdataOut_Concatenated_reg[1][5] cacheDataOut_SOUTH[5] 1141 FE_PHN234_N5386 clk
+ TLATXLTS
XdataOut_Concatenated_reg[1][4] cacheDataOut_SOUTH[4] 1142 FE_PHN237_N5385 clk
+ TLATXLTS
XdataOut_Concatenated_reg[1][3] cacheDataOut_SOUTH[3] 1143 N5384 clk TLATXLTS
XdataOut_Concatenated_reg[1][2] cacheDataOut_SOUTH[2] 1144 FE_PHN266_N5383 clk
+ TLATXLTS
XdataOut_Concatenated_reg[1][1] cacheDataOut_SOUTH[1] 1145 FE_PHN235_N5382 clk
+ TLATXLTS
XdataOut_Concatenated_reg[1][0] cacheDataOut_SOUTH[0] 1146 N5381 clk TLATXLTS
XdataOut_Concatenated_reg[0][5] cacheDataOut_NORTH[5] 1147 N5378 clk TLATXLTS
XdataOut_Concatenated_reg[0][4] cacheDataOut_NORTH[4] 1148 FE_PHN230_N5377 clk
+ TLATXLTS
XdataOut_Concatenated_reg[0][3] cacheDataOut_NORTH[3] 1149 FE_PHN227_N5376 clk
+ TLATXLTS
XdataOut_Concatenated_reg[0][2] cacheDataOut_NORTH[2] 1150 FE_PHN226_N5375 clk
+ TLATXLTS
XdataOut_Concatenated_reg[0][1] cacheDataOut_NORTH[1] 1151 N5374 clk TLATXLTS
XdataOut_Concatenated_reg[0][0] cacheDataOut_NORTH[0] 1152 FE_PHN225_N5373 clk
+ TLATXLTS
XrequesterAddressOut_Concatenated_reg[3][3] requesterAddressOut_WEST[3] clk
+ n1171 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[3][2] requesterAddressOut_WEST[2] clk
+ n1170 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[3][1] requesterAddressOut_WEST[1] clk
+ n1169 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[2][3] requesterAddressOut_EAST[3] clk
+ n1167 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[2][2] requesterAddressOut_EAST[2] clk
+ n1166 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[2][1] requesterAddressOut_EAST[1] clk
+ n1165 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[1][3] requesterAddressOut_SOUTH[3] clk
+ n1163 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[1][2] requesterAddressOut_SOUTH[2] clk
+ n1162 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[1][1] requesterAddressOut_SOUTH[1] clk
+ n1161 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[3][0] requesterAddressOut_WEST[0] clk
+ n1168 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[2][0] requesterAddressOut_EAST[0] clk
+ n1164 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[1][0] requesterAddressOut_SOUTH[0] clk
+ n1160 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[0][3] requesterAddressOut_NORTH[3] clk
+ n1159 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[0][2] requesterAddressOut_NORTH[2] clk
+ n1158 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[0][1] requesterAddressOut_NORTH[1] clk
+ n1157 DFFQX1TS
XrequesterAddressOut_Concatenated_reg[0][0] requesterAddressOut_NORTH[0] clk
+ n1156 DFFQX1TS
XprevRequesterPort_A_reg[1] n4 n17 clk n1355 VDD VDD DFFNSRX1TS
XprevRequesterPort_A_reg[0] prevRequesterPort_A[0] n6 clk n1356 VDD VDD
+ DFFNSRX1TS
XprevRequesterPort_B_reg[1] prevRequesterPort_B[1] n5 clk n1357 VDD VDD
+ DFFNSRX1TS
XprevRequesterPort_B_reg[0] n7 n19 clk n1358 VDD VDD DFFNSRX1TS
XmemWrite_B_reg memWrite_B 1153 clk n1202 VDD VDD DFFNSRX1TS
XmemWrite_A_reg memWrite_A 1154 clk n1181 VDD VDD DFFNSRX1TS
XcacheDataIn_A_reg[5] cacheDataIn_A[5] 1155 clk n1196 VDD VDD DFFNSRX1TS
XcacheDataIn_A_reg[4] cacheDataIn_A[4] 1156 clk n1197 VDD VDD DFFNSRX1TS
XcacheDataIn_A_reg[3] cacheDataIn_A[3] 1157 clk n1198 VDD VDD DFFNSRX1TS
XcacheDataIn_A_reg[2] cacheDataIn_A[2] 1158 clk n1199 VDD VDD DFFNSRX1TS
XcacheDataIn_A_reg[1] cacheDataIn_A[1] 1159 clk n1200 VDD VDD DFFNSRX1TS
XcacheDataIn_A_reg[0] cacheDataIn_A[0] 1160 clk n1201 VDD VDD DFFNSRX1TS
XcacheAddressIn_B_reg[7] cacheAddressIn_B[7] 1161 clk n1195 VDD VDD DFFNSRX1TS
XcacheAddressIn_B_reg[6] cacheAddressIn_B[6] 1162 clk n1194 VDD VDD DFFNSRX1TS
XcacheAddressIn_B_reg[5] cacheAddressIn_B[5] 1163 clk n1193 VDD VDD DFFNSRX1TS
XcacheAddressIn_B_reg[4] cacheAddressIn_B[4] 1164 clk n1192 VDD VDD DFFNSRX1TS
XcacheAddressIn_B_reg[3] cacheAddressIn_B[3] 1165 clk n1191 VDD VDD DFFNSRX1TS
XcacheAddressIn_B_reg[2] cacheAddressIn_B[2] 1166 clk n1190 VDD VDD DFFNSRX1TS
XcacheAddressIn_B_reg[1] cacheAddressIn_B[1] 1167 clk n1189 VDD VDD DFFNSRX1TS
XcacheAddressIn_B_reg[0] cacheAddressIn_B[0] 1168 clk n1188 VDD VDD DFFNSRX1TS
XcacheDataIn_B_reg[5] cacheDataIn_B[5] 1169 clk n1187 VDD VDD DFFNSRX1TS
XcacheDataIn_B_reg[4] cacheDataIn_B[4] 1170 clk n1186 VDD VDD DFFNSRX1TS
XcacheDataIn_B_reg[3] cacheDataIn_B[3] 1171 clk n1185 VDD VDD DFFNSRX1TS
XcacheDataIn_B_reg[2] cacheDataIn_B[2] 1172 clk n1184 VDD VDD DFFNSRX1TS
XcacheDataIn_B_reg[1] cacheDataIn_B[1] 1173 clk n1183 VDD VDD DFFNSRX1TS
XcacheDataIn_B_reg[0] cacheDataIn_B[0] 1174 clk n1182 VDD VDD DFFNSRX1TS
XcacheAddressIn_A_reg[7] cacheAddressIn_A[7] 1175 clk n1180 VDD VDD DFFNSRX1TS
XcacheAddressIn_A_reg[6] cacheAddressIn_A[6] 1176 clk n1179 VDD VDD DFFNSRX1TS
XcacheAddressIn_A_reg[5] cacheAddressIn_A[5] 1177 clk n1178 VDD VDD DFFNSRX1TS
XcacheAddressIn_A_reg[4] cacheAddressIn_A[4] 1178 clk n1177 VDD VDD DFFNSRX1TS
XcacheAddressIn_A_reg[3] cacheAddressIn_A[3] 1179 clk n1176 VDD VDD DFFNSRX1TS
XcacheAddressIn_A_reg[2] cacheAddressIn_A[2] 1180 clk n1175 VDD VDD DFFNSRX1TS
XcacheAddressIn_A_reg[1] cacheAddressIn_A[1] 1181 clk n1174 VDD VDD DFFNSRX1TS
XcacheAddressIn_A_reg[0] cacheAddressIn_A[0] 1182 clk n1173 VDD VDD DFFNSRX1TS
XnextEmptyBuffer_reg[2] n834 n830 clk n1209 VDD VDD DFFNSRX1TS
XisWrite_reg[5] isWrite[5] n833 clk n1214 VDD VDD DFFNSRX1TS
XprevRequesterAddress_B_reg[2] prevRequesterAddress_B[2] n827 clk n1360 VDD VDD
+ DFFNSRX1TS
XprevRequesterAddress_B_reg[1] prevRequesterAddress_B[1] n828 clk n1361 VDD VDD
+ DFFNSRX1TS
XprevRequesterAddress_B_reg[0] prevRequesterAddress_B[0] n829 clk n1362 VDD VDD
+ DFFNSRX1TS
XprevRequesterAddress_B_reg[3] prevRequesterAddress_B[3] n826 clk n1359 VDD VDD
+ DFFNSRX1TS
XisWrite_reg[1] isWrite[1] n832 clk n1218 VDD VDD DFFNSRX1TS
XU4 n39 N741 FE_DBTN182_n35 NOR2XLTS
XU5 n35 n50 n834 NOR2XLTS
XU6 n138 n41 n137 NOR2XLTS
XU8 n674 memWrite_NORTH INVX2TS
XU9 n633 n646 INVX2TS
XU12 n501 n34 INVX2TS
XU13 n192 prevRequesterPort_A[0] n191 NOR2XLTS
XU15 n346 n345 n348 n353 NOR3BX1TS
XU16 n348 n349 n351 NAND2X1TS
XU19 n352 reset n351 NOR2X1TS
XU20 n13 n633 n45 XOR2X1TS
XU22 n51 n501 n32 NOR2X1TS
XU23 n672 n512 n579 NOR2X1TS
XU24 n32 memRead_EAST memWrite_EAST NOR2X1TS
XU25 n3 n26 n193 n7 NAND3X1TS
XU26 n33 memRead_NORTH memWrite_NORTH NOR2X1TS
XU27 n41 n32 n47 NOR2X1TS
XU28 n440 FE_DBTN184_n18 n16 n46 NOR3XLTS
XU29 n341 n333 n40 XOR2XLTS
XU30 n575 n51 n343 n77 NAND3XLTS
XU31 n342 n32 n77 NOR2XLTS
XU32 n337 n20 N742 n579 NAND3XLTS
XU33 n48 n40 n47 NOR2XLTS
XU34 n653 n33 n518 n673 n46 AOI211XLTS
XU35 n673 FE_DBTN185_n16 FE_DBTN184_n18 n515 NOR3XLTS
XU36 n436 n32 n18 n512 n579 NOR4BXLTS
XU37 n514 memRead_SOUTH memWrite_SOUTH NOR2X1TS
XU38 n340 FE_DBTN184_n18 n80 NOR2XLTS
XU39 n353 n33 n40 n338 n337 AOI211XLTS
XU40 n343 n14 n78 NOR2XLTS
XU42 n644 n16 n134 NAND2X1TS
XU43 n642 FE_DBTN184_n18 n640 NOR2XLTS
XU44 n676 memWrite_SOUTH INVX2TS
XU45 n651 n793 n39 n673 NAND3XLTS
XU46 n524 n672 n32 n677 NOR3BXLTS
XU48 n623 n18 n581 n536 NAND3XLTS
XU49 n354 n353 n793 CLKAND2X2TS
XU50 n461 cacheAddressIn_EAST[5] INVX2TS
XU51 n465 cacheAddressIn_EAST[6] INVX2TS
XU52 n53 n575 n440 n254 NOR3BXLTS
XU53 n254 n46 reset OR2X1TS
XU54 n611 n622 n54 n610 OAI21XLTS
XU55 n1278 n445 n831 n444 n443 OAI211XLTS
XU56 n1279 reset n449 n448 OAI21XLTS
XU57 n78 n40 n433 n433 n40 AOI2BB2XLTS
XU58 n433 n34 n672 NOR2X1TS
XU59 n83 n14 n342 CLKAND2X2TS
XU60 n28 n7 n193 n27 NOR3BXLTS
XU61 n23 n193 n7 n21 NOR3BXLTS
XU62 n622 memWrite_WEST INVX2TS
XU63 n609 n18 FE_DBTN185_n16 FE_DBTN187_n13 n46 AOI31XLTS
XU64 n241 n133 n500 NOR2XLTS
XU65 n137 FE_DBTN173_n254 n134 n681 NAND3XLTS
XU66 n85 n84 n793 CLKAND2X2TS
XU67 n160 cacheAddressIn_EAST[4] INVX2TS
XU68 n164 cacheAddressIn_EAST[7] INVX2TS
XU69 n544 n609 n36 OR2X1TS
XU70 n648 n650 n649 n647 OAI21XLTS
XU71 n627 memRead_EAST memRead_SOUTH n674 n676 memRead_EAST OAI32X1TS
XU72 n1173 n774 n773 n772 NAND3XLTS
XU73 n1174 n766 n765 n764 NAND3XLTS
XU74 n1175 n758 n757 n756 NAND3XLTS
XU75 n1176 n750 n749 n748 NAND3XLTS
XU76 n1177 n742 n741 n740 NAND3XLTS
XU77 n1178 n736 n735 n734 NAND3XLTS
XU78 n1179 n730 n729 n728 NAND3XLTS
XU79 n1180 n725 n724 n723 NAND3XLTS
XU80 n1201 n689 n688 n687 NAND3XLTS
XU81 n1200 n694 n693 n692 NAND3XLTS
XU82 n1199 n698 n697 n696 NAND3XLTS
XU83 n1198 n705 n704 n703 NAND3XLTS
XU84 n1197 n710 n709 n708 NAND3XLTS
XU85 n1196 n716 n715 n714 NAND3XLTS
XU86 n1202 FE_DBTN175_n681 memWrite_B n681 n680 AO22XLTS
XU87 n1358 n501 n500 n499 n498 OAI211XLTS
XU88 n1357 n225 n500 n496 n498 OAI211XLTS
XU89 n1356 FE_DBTN167_n702 n522 n651 NAND3BXLTS
XU90 n1355 n524 n525 n651 NAND3BXLTS
XU91 n1208 n657 n656 n655 NAND3XLTS
XU92 n1207 n660 n659 n658 NAND3XLTS
XU93 n1206 n664 n663 n662 NAND3XLTS
XU94 n1205 n670 n669 n668 NAND3XLTS
XU95 n1204 n16 n437 n679 n677 AOI211XLTS
XU96 n1219 n832 n222 n220 OAI21XLTS
XU97 n1273 n623 n583 n582 NAND3XLTS
XU98 n1276 n222 n831 n221 OAI21XLTS
XU99 n1306 cacheAddressIn_NORTH[0] FE_DBTN172_n367 n358 AO21XLTS
XU100 n1305 FE_DBTN172_n367 cacheAddressIn_NORTH[1] n396 AO21XLTS
XU101 n396 n350 n395 n394 n393 OAI211XLTS
XU102 n1304 FE_DBTN172_n367 cacheAddressIn_NORTH[2] n387 AO21XLTS
XU103 n387 n350 n386 n385 n384 OAI211XLTS
XU104 n1303 FE_DBTN172_n367 cacheAddressIn_NORTH[3] n431 AO21XLTS
XU105 n431 n350 n429 n428 n427 OAI211XLTS
XU106 n1302 FE_DBTN172_n367 cacheAddressIn_NORTH[4] n373 AO21XLTS
XU107 n1301 FE_DBTN172_n367 cacheAddressIn_NORTH[5] n366 AO21XLTS
XU108 n1300 FE_DBTN172_n367 cacheAddressIn_NORTH[6] n362 AO21XLTS
XU109 n1299 FE_DBTN172_n367 cacheAddressIn_NORTH[7] n377 AO21XLTS
XU110 n1237 FE_DBTN172_n367 dataIn_NORTH[0] n402 AO21XLTS
XU111 n402 n350 n401 n400 n399 OAI211XLTS
XU112 n1236 FE_DBTN172_n367 dataIn_NORTH[1] n381 AO21XLTS
XU113 n1235 FE_DBTN172_n367 dataIn_NORTH[2] n414 AO21XLTS
XU114 n414 n350 n412 n411 n410 OAI211XLTS
XU115 n1234 FE_DBTN172_n367 dataIn_NORTH[3] n408 AO21XLTS
XU116 n408 n350 n407 n406 n405 OAI211XLTS
XU117 n1233 FE_DBTN172_n367 dataIn_NORTH[4] n391 AO21XLTS
XU118 n391 n350 n390 n389 n388 OAI211XLTS
XU119 n1232 FE_DBTN172_n367 dataIn_NORTH[5] n422 AO21XLTS
XU120 n422 n350 n420 n419 n418 OAI211XLTS
XU121 n1337 n473 FE_DBTN180_n67 n471 n470 OAI211XLTS
XU122 n1336 n480 FE_DBTN180_n67 n478 n477 OAI211XLTS
XU123 n1333 n461 FE_DBTN180_n67 n460 n459 OAI211XLTS
XU124 n1332 n465 FE_DBTN180_n67 n464 n463 OAI211XLTS
XU125 n1261 n468 FE_DBTN180_n67 n467 n466 OAI211XLTS
XU126 n1259 n455 FE_DBTN180_n67 n454 n453 OAI211XLTS
XU127 n1257 n488 FE_DBTN180_n67 n486 n485 OAI211XLTS
XU128 n1256 n495 FE_DBTN180_n67 n493 n492 OAI211XLTS
XU129 n1281 FE_DBTN170_n612 requesterPortBuffer[1][0] n572 AO21XLTS
XU130 n1280 FE_DBTN170_n612 requesterPortBuffer[1][1] n577 AO21XLTS
XU131 n1274 n254 n831 n219 OAI21XLTS
XU132 N5316 n192 prevMemRead_A FE_DBTN174_n205 prevMemRead_B AO22XLTS
XU133 N5324 n27 prevMemRead_A n28 prevMemRead_B AO22XLTS
XU134 N5332 n21 prevMemRead_A n23 prevMemRead_B AO22XLTS
XU135 n27 n521 n4 NOR2BX1TS
XU136 n21 n4 n521 NOR2BX1TS
XU137 n56 n55 n54 NOR2BX1TS
XU138 n547 n441 reset NOR2BX1TS
XU139 n34 n33 n514 NOR2XLTS
XU141 n14 n34 n48 n633 OA21XLTS
XU142 n15 reset n684 OR2X1TS
XU143 n16 n32 n672 n501 OA21XLTS
XU144 n86 n340 n341 reset FE_DBTN187_n13 NOR4BXLTS
XU145 n654 n653 n520 NOR2BX1TS
XU146 n133 FE_DBTN185_n16 n333 FE_DBTN184_n18 NOR3XLTS
XU147 n18 memRead_WEST memWrite_WEST OR2X1TS
XU148 n59 n35 reset NOR2XLTS
XU149 n40 N741 n39 n215 OAI21XLTS
XU150 n20 n830 INVX2TS
XU158 n521 n6 INVX2TS
XU165 N5394 n21 cacheDataOut_A[5] n23 cacheDataOut_B[5] AO22X2TS
XU169 N5393 n21 cacheDataOut_A[4] n23 cacheDataOut_B[4] AO22X2TS
XU174 N5392 n21 cacheDataOut_A[3] n23 cacheDataOut_B[3] AO22X2TS
XU178 N5391 n21 cacheDataOut_A[2] n23 cacheDataOut_B[2] AO22X2TS
XU181 N5390 n21 cacheDataOut_A[1] n23 cacheDataOut_B[1] AO22X2TS
XU184 N5389 n21 cacheDataOut_A[0] n23 cacheDataOut_B[0] AO22X2TS
XU185 n26 n521 n4 NAND2X1TS
XU188 FE_PHN221_N5402 FE_DBTN183_n26 cacheDataOut_A[5] FE_DBTN188_n3
+ cacheDataOut_B[5] AO22X2TS
XU191 N5401 FE_DBTN183_n26 cacheDataOut_A[4] FE_DBTN188_n3 cacheDataOut_B[4]
+ AO22X2TS
XU193 FE_PHN219_N5400 FE_DBTN183_n26 cacheDataOut_A[3] FE_DBTN188_n3
+ cacheDataOut_B[3] AO22X2TS
XU194 N5399 FE_DBTN183_n26 cacheDataOut_A[2] FE_DBTN188_n3 cacheDataOut_B[2]
+ AO22X2TS
XU196 FE_PHN222_N5398 FE_DBTN183_n26 cacheDataOut_A[1] FE_DBTN188_n3
+ cacheDataOut_B[1] AO22X2TS
XU197 N5397 FE_DBTN183_n26 cacheDataOut_A[0] FE_DBTN188_n3 cacheDataOut_B[0]
+ AO22X2TS
XU202 N5386 n27 cacheDataOut_A[5] n28 cacheDataOut_B[5] AO22X2TS
XU204 N5385 n27 cacheDataOut_A[4] n28 cacheDataOut_B[4] AO22X2TS
XU206 FE_PHN236_N5384 n27 cacheDataOut_A[3] n28 cacheDataOut_B[3] AO22X2TS
XU208 N5383 n27 cacheDataOut_A[2] n28 cacheDataOut_B[2] AO22X2TS
XU210 N5382 n27 cacheDataOut_A[1] n28 cacheDataOut_B[1] AO22X2TS
XU211 FE_PHN233_N5381 n27 cacheDataOut_A[0] n28 cacheDataOut_B[0] AO22X2TS
XU217 n512 n33 INVX2TS
XU218 n579 n514 INVX2TS
XU220 n50 n12 INVX2TS
XU222 n215 n35 N741 NAND2X1TS
XU223 n36 n215 INVX2TS
XU226 n646 n50 n36 NOR2XLTS
XU233 n47 n433 INVX2TS
XU234 n225 n41 INVX2TS
XU236 n515 n32 n47 n41 AOI21X1TS
XU237 n333 n515 INVX2TS
XU238 n44 n40 n333 NOR2X1TS
XU240 n640 n51 INVX2TS
XU241 n45 n44 FE_DBTN185_n16 n640 n40 OAI22X1TS
XU243 n46 n39 INVX2TS
XU245 n793 reset INVX2TS
XU250 n77 n50 n34 n834 OAI21XLTS
XU259 n55 reset n53 NOR2XLTS
XU260 n67 n609 n55 CLKAND2X2TS
XU262 n372 cacheAddressIn_WEST[4] INVX2TS
XU264 n54 n341 n39 NAND2X1TS
XU268 n61 cacheAddressIn_WEST[4] n56 n53 addressToWriteBuffer[1][4] AOI22X1TS
XU269 n57 reset n215 OR2X1TS
XU278 n60 FE_DBTN181_n57 addressToWriteBuffer[2][4] n59
+ addressToWriteBuffer[3][4] AOI22X1TS
XU279 n1334 n160 FE_DBTN180_n67 n61 n60 OAI211XLTS
XU280 n156 dataIn_EAST[3] INVX2TS
XU282 n407 dataIn_WEST[3] INVX2TS
XU284 n64 dataIn_WEST[3] n56 n53 dataToWriteBuffer[1][3] AOI22X1TS
XU286 n63 FE_DBTN181_n57 dataToWriteBuffer[2][3] n59 dataToWriteBuffer[3][3]
+ AOI22X1TS
XU287 n1258 n156 FE_DBTN180_n67 n64 n63 OAI211XLTS
XU289 n376 cacheAddressIn_WEST[7] INVX2TS
XU291 n66 cacheAddressIn_WEST[7] n56 n53 addressToWriteBuffer[1][7] AOI22X1TS
XU293 n65 FE_DBTN181_n57 addressToWriteBuffer[2][7] n59
+ addressToWriteBuffer[3][7] AOI22X1TS
XU294 n1331 n164 FE_DBTN180_n67 n66 n65 OAI211XLTS
XU295 n143 cacheAddressIn_EAST[3] INVX2TS
XU297 n429 cacheAddressIn_WEST[3] INVX2TS
XU300 n70 cacheAddressIn_WEST[3] n56 n53 addressToWriteBuffer[1][3] AOI22X1TS
XU302 n69 FE_DBTN181_n57 addressToWriteBuffer[2][3] n59
+ addressToWriteBuffer[3][3] AOI22X1TS
XU303 n1335 n143 FE_DBTN180_n67 n70 n69 OAI211XLTS
XU304 n182 dataIn_EAST[1] INVX2TS
XU305 n380 dataIn_WEST[1] INVX2TS
XU308 n73 dataIn_WEST[1] n56 n53 dataToWriteBuffer[1][1] AOI22X1TS
XU310 n72 FE_DBTN181_n57 dataToWriteBuffer[2][1] n59 dataToWriteBuffer[3][1]
+ AOI22X1TS
XU311 n1260 n182 FE_DBTN180_n67 n73 n72 OAI211XLTS
XU312 n190 cacheAddressIn_EAST[0] INVX2TS
XU313 n357 cacheAddressIn_WEST[0] INVX2TS
XU315 n75 cacheAddressIn_WEST[0] n56 n53 addressToWriteBuffer[1][0] AOI22X1TS
XU316 n74 FE_DBTN181_n57 addressToWriteBuffer[2][0] n59
+ addressToWriteBuffer[3][0] AOI22X1TS
XU317 n1338 n190 FE_DBTN180_n67 n75 n74 OAI211XLTS
XU319 n93 n342 n14 n78 n793 AND4X1TS
XU321 n488 dataIn_EAST[4] INVX2TS
XU324 n80 FE_DBTN185_n16 N742 n834 OAI21XLTS
XU325 n82 n340 FE_DBTN187_n13 NOR2BX1TS
XU326 n338 n33 n40 NOR2XLTS
XU327 n84 n338 n337 NOR2BX1TS
XU328 n98 reset n83 n82 n84 OR4X2TS
XU332 n88 dataToWriteBuffer[6][4] FE_DBTN178_n98 dataIn_SOUTH[4] n85 AOI22X1TS
XU336 n87 dataIn_WEST[4] n86 NAND2X1TS
XU337 n1227 FE_DBTN179_n93 n488 n88 n87 OAI211XLTS
XU340 n90 dataToWriteBuffer[6][3] FE_DBTN178_n98 dataIn_SOUTH[3] n85 AOI22X1TS
XU342 n89 dataIn_WEST[3] n86 NAND2X1TS
XU343 n1228 FE_DBTN179_n93 n156 n90 n89 OAI211XLTS
XU346 n92 addressToWriteBuffer[6][4] FE_DBTN178_n98 cacheAddressIn_SOUTH[4] n85
+ AOI22X1TS
XU347 n91 cacheAddressIn_WEST[4] n86 NAND2X1TS
XU348 n1294 FE_DBTN179_n93 n160 n92 n91 OAI211XLTS
XU351 n95 addressToWriteBuffer[6][6] FE_DBTN178_n98 cacheAddressIn_SOUTH[6] n85
+ AOI22X1TS
XU352 n94 cacheAddressIn_WEST[6] n86 NAND2X1TS
XU353 n1292 FE_DBTN179_n93 n465 n95 n94 OAI211XLTS
XU354 n97 addressToWriteBuffer[6][7] FE_DBTN178_n98 cacheAddressIn_SOUTH[7] n85
+ AOI22X1TS
XU355 n96 cacheAddressIn_WEST[7] n86 NAND2X1TS
XU356 n1291 FE_DBTN179_n93 n164 n97 n96 OAI211XLTS
XU357 n473 cacheAddressIn_EAST[1] INVX2TS
XU360 n102 addressToWriteBuffer[6][1] FE_DBTN178_n98 cacheAddressIn_SOUTH[1]
+ n85 AOI22X1TS
XU362 n101 cacheAddressIn_WEST[1] n86 NAND2X1TS
XU363 n1297 FE_DBTN179_n93 n473 n102 n101 OAI211XLTS
XU364 n495 dataIn_EAST[5] INVX2TS
XU365 n104 dataToWriteBuffer[6][5] FE_DBTN178_n98 dataIn_SOUTH[5] n85 AOI22X1TS
XU366 n103 dataIn_WEST[5] n86 NAND2X1TS
XU367 n1226 FE_DBTN179_n93 n495 n104 n103 OAI211XLTS
XU368 n106 addressToWriteBuffer[6][5] FE_DBTN178_n98 cacheAddressIn_SOUTH[5]
+ n85 AOI22X1TS
XU369 n105 cacheAddressIn_WEST[5] n86 NAND2X1TS
XU370 n1293 FE_DBTN179_n93 n461 n106 n105 OAI211XLTS
XU371 n480 cacheAddressIn_EAST[2] INVX2TS
XU372 n108 addressToWriteBuffer[6][2] FE_DBTN178_n98 cacheAddressIn_SOUTH[2]
+ n85 AOI22X1TS
XU373 n107 cacheAddressIn_WEST[2] n86 NAND2X1TS
XU374 n1296 FE_DBTN179_n93 n480 n108 n107 OAI211XLTS
XU375 n110 addressToWriteBuffer[6][0] FE_DBTN178_n98 cacheAddressIn_SOUTH[0]
+ n85 AOI22X1TS
XU376 n109 cacheAddressIn_WEST[0] n86 NAND2X1TS
XU377 n1298 FE_DBTN179_n93 n190 n110 n109 OAI211XLTS
XU378 n455 dataIn_EAST[2] INVX2TS
XU379 n114 dataToWriteBuffer[6][2] FE_DBTN178_n98 dataIn_SOUTH[2] n85 AOI22X1TS
XU380 n113 dataIn_WEST[2] n86 NAND2X1TS
XU381 n1229 FE_DBTN179_n93 n455 n114 n113 OAI211XLTS
XU382 n468 dataIn_EAST[0] INVX2TS
XU383 n119 dataToWriteBuffer[6][0] FE_DBTN178_n98 dataIn_SOUTH[0] n85 AOI22X1TS
XU384 n118 dataIn_WEST[0] n86 NAND2X1TS
XU385 n1231 FE_DBTN179_n93 n468 n119 n118 OAI211XLTS
XU386 n125 dataToWriteBuffer[6][1] FE_DBTN178_n98 dataIn_SOUTH[1] n85 AOI22X1TS
XU387 n124 dataIn_WEST[1] n86 NAND2X1TS
XU388 n1230 FE_DBTN179_n93 n182 n125 n124 OAI211XLTS
XU389 n131 addressToWriteBuffer[6][3] FE_DBTN178_n98 cacheAddressIn_SOUTH[3]
+ n85 AOI22X1TS
XU390 n130 cacheAddressIn_WEST[3] n86 NAND2X1TS
XU391 n1295 FE_DBTN179_n93 n143 n131 n130 OAI211XLTS
XU393 n146 n41 FE_DBTN173_n254 CLKAND2X2TS
XU395 n420 dataIn_WEST[5] INVX2TS
XU400 n134 n133 INVX2TS
XU401 n498 FE_DBTN173_n254 n133 NAND2X1TS
XU405 n445 FE_DBTN182_n35 n793 NAND2X1TS
XU406 n536 n445 INVX2TS
XU411 n140 dataIn_WEST[5] FE_DBTN176_n498 dataToWriteBuffer[1][5] n536
+ AOI22X1TS
XU414 n223 n39 n644 FE_DBTN182_n35 AOI21X1TS
XU415 n681 n793 n223 NAND2X1TS
XU419 n139 dataIn_SOUTH[5] n138 FE_DBTN175_n681 cacheDataIn_B[5] AOI22X1TS
XU420 n1187 n495 FE_DBTN177_n146 n140 n139 OAI211XLTS
XU425 n142 cacheAddressIn_WEST[3] FE_DBTN176_n498 addressToWriteBuffer[1][3]
+ n536 AOI22X1TS
XU427 n141 cacheAddressIn_SOUTH[3] n138 FE_DBTN175_n681 cacheAddressIn_B[3]
+ AOI22X1TS
XU428 n1191 n143 FE_DBTN177_n146 n142 n141 OAI211XLTS
XU430 n386 cacheAddressIn_WEST[2] INVX2TS
XU434 n145 cacheAddressIn_WEST[2] FE_DBTN176_n498 addressToWriteBuffer[1][2]
+ n536 AOI22X1TS
XU436 n144 cacheAddressIn_SOUTH[2] n138 FE_DBTN175_n681 cacheAddressIn_B[2]
+ AOI22X1TS
XU437 n1190 n480 FE_DBTN177_n146 n145 n144 OAI211XLTS
XU439 n361 cacheAddressIn_WEST[6] INVX2TS
XU442 n148 cacheAddressIn_WEST[6] FE_DBTN176_n498 addressToWriteBuffer[1][6]
+ n536 AOI22X1TS
XU444 n147 cacheAddressIn_SOUTH[6] n138 FE_DBTN175_n681 cacheAddressIn_B[6]
+ AOI22X1TS
XU445 n1194 n465 FE_DBTN177_n146 n148 n147 OAI211XLTS
XU446 n395 cacheAddressIn_WEST[1] INVX2TS
XU449 n151 cacheAddressIn_WEST[1] FE_DBTN176_n498 addressToWriteBuffer[1][1]
+ n536 AOI22X1TS
XU452 n150 cacheAddressIn_SOUTH[1] n138 FE_DBTN175_n681 cacheAddressIn_B[1]
+ AOI22X1TS
XU453 n1189 n473 FE_DBTN177_n146 n151 n150 OAI211XLTS
XU454 n390 dataIn_WEST[4] INVX2TS
XU457 n153 dataIn_WEST[4] FE_DBTN176_n498 dataToWriteBuffer[1][4] n536
+ AOI22X1TS
XU458 n152 dataIn_SOUTH[4] n138 FE_DBTN175_n681 cacheDataIn_B[4] AOI22X1TS
XU459 n1186 n488 FE_DBTN177_n146 n153 n152 OAI211XLTS
XU460 n155 dataIn_WEST[3] FE_DBTN176_n498 dataToWriteBuffer[1][3] n536
+ AOI22X1TS
XU461 n154 dataIn_SOUTH[3] n138 FE_DBTN175_n681 cacheDataIn_B[3] AOI22X1TS
XU462 n1185 n156 FE_DBTN177_n146 n155 n154 OAI211XLTS
XU463 n159 cacheAddressIn_WEST[4] FE_DBTN176_n498 addressToWriteBuffer[1][4]
+ n536 AOI22X1TS
XU465 n158 cacheAddressIn_SOUTH[4] n138 FE_DBTN175_n681 cacheAddressIn_B[4]
+ AOI22X1TS
XU466 n1192 n160 FE_DBTN177_n146 n159 n158 OAI211XLTS
XU467 n163 cacheAddressIn_WEST[7] FE_DBTN176_n498 addressToWriteBuffer[1][7]
+ n536 AOI22X1TS
XU468 n162 cacheAddressIn_SOUTH[7] n138 FE_DBTN175_n681 cacheAddressIn_B[7]
+ AOI22X1TS
XU469 n1195 n164 FE_DBTN177_n146 n163 n162 OAI211XLTS
XU470 n401 dataIn_WEST[0] INVX2TS
XU473 n168 dataIn_WEST[0] FE_DBTN176_n498 dataToWriteBuffer[1][0] n536
+ AOI22X1TS
XU474 n167 dataIn_SOUTH[0] n138 FE_DBTN175_n681 cacheDataIn_B[0] AOI22X1TS
XU475 n1182 n468 FE_DBTN177_n146 n168 n167 OAI211XLTS
XU476 n365 cacheAddressIn_WEST[5] INVX2TS
XU478 n172 cacheAddressIn_WEST[5] FE_DBTN176_n498 addressToWriteBuffer[1][5]
+ n536 AOI22X1TS
XU479 n171 cacheAddressIn_SOUTH[5] n138 FE_DBTN175_n681 cacheAddressIn_B[5]
+ AOI22X1TS
XU480 n1193 n461 FE_DBTN177_n146 n172 n171 OAI211XLTS
XU481 n412 dataIn_WEST[2] INVX2TS
XU483 n175 dataIn_WEST[2] FE_DBTN176_n498 dataToWriteBuffer[1][2] n536
+ AOI22X1TS
XU484 n174 dataIn_SOUTH[2] n138 FE_DBTN175_n681 cacheDataIn_B[2] AOI22X1TS
XU485 n1184 n455 FE_DBTN177_n146 n175 n174 OAI211XLTS
XU486 n180 dataIn_WEST[1] FE_DBTN176_n498 dataToWriteBuffer[1][1] n536
+ AOI22X1TS
XU487 n179 dataIn_SOUTH[1] n138 FE_DBTN175_n681 cacheDataIn_B[1] AOI22X1TS
XU488 n1183 n182 FE_DBTN177_n146 n180 n179 OAI211XLTS
XU489 n188 cacheAddressIn_WEST[0] FE_DBTN176_n498 addressToWriteBuffer[1][0]
+ n536 AOI22X1TS
XU490 n187 cacheAddressIn_SOUTH[0] n138 FE_DBTN175_n681 cacheAddressIn_B[0]
+ AOI22X1TS
XU491 n1188 n190 FE_DBTN177_n146 n188 n187 OAI211XLTS
XU492 n194 n19 INVX2TS
XU493 n193 n5 INVX2TS
XU494 n191 n17 INVX2TS
XU497 n205 n194 n193 n192 OR3X1TS
XU500 n203 FE_DBTN174_n205 n793 NAND2X1TS
XU501 n801 n8 INVX2TS
XU502 n201 n192 reset NOR2BX1TS
XU505 n200 reset n192 FE_DBTN174_n205 NOR3XLTS
XU506 n197 n801 n201 n200 requesterAddressOut_NORTH[3] AOI22X1TS
XU507 n1159 n826 n203 n197 OAI21XLTS
XU508 n807 n9 INVX2TS
XU509 n198 n807 n201 n200 requesterAddressOut_NORTH[2] AOI22X1TS
XU510 n1158 n827 n203 n198 OAI21XLTS
XU511 n810 n10 INVX2TS
XU512 n199 n810 n201 n200 requesterAddressOut_NORTH[1] AOI22X1TS
XU513 n1157 n828 n203 n199 OAI21XLTS
XU514 n815 n11 INVX2TS
XU515 n202 n815 n201 n200 requesterAddressOut_NORTH[0] AOI22X1TS
XU516 n1156 n829 n203 n202 OAI21XLTS
XU519 N5373 n192 cacheDataOut_A[0] FE_DBTN174_n205 cacheDataOut_B[0] AO22X2TS
XU520 FE_PHN228_N5374 n192 cacheDataOut_A[1] FE_DBTN174_n205 cacheDataOut_B[1]
+ AO22X2TS
XU521 N5375 n192 cacheDataOut_A[2] FE_DBTN174_n205 cacheDataOut_B[2] AO22X2TS
XU522 N5376 n192 cacheDataOut_A[3] FE_DBTN174_n205 cacheDataOut_B[3] AO22X2TS
XU523 n216 n50 n834 N741 NAND3XLTS
XU524 n581 n216 INVX2TS
XU526 n218 n581 n536 NAND2X1TS
XU527 n631 n436 n216 n215 n793 OAI211XLTS
XU528 n629 n631 INVX2TS
XU529 n217 n629 requesterPortBuffer[5][1] NAND2X1TS
XU530 n1272 n32 n218 n217 n623 OAI211XLTS
XU531 n222 n793 n36 NAND2X1TS
XU532 n250 n222 INVX2TS
XU536 n219 n250 requesterPortBuffer[5][1] NAND2X1TS
XU539 n220 FE_DBTN173_n254 isWrite[0] n536 isWrite[2] AOI22X1TS
XU540 n221 FE_DBTN173_n254 requesterPortBuffer[3][1] n536
+ requesterPortBuffer[5][1] AOI22X1TS
XU541 n244 reset n223 NOR2XLTS
XU542 n497 n244 INVX2TS
XU544 n230 requesterAddressIn_WEST[3] FE_DBTN176_n498
+ requesterAddressBuffer[1][3] n536 AOI22X1TS
XU547 n500 FE_DBTN173_n254 n644 NAND2X1TS
XU548 n229 n41 requesterAddressIn_SOUTH[3] n225 requesterAddressIn_EAST[3] n241
+ OAI221XLTS
XU549 n1359 n244 n826 n230 n229 OAI211XLTS
XU550 n235 requesterAddressIn_WEST[0] FE_DBTN176_n498
+ requesterAddressBuffer[1][0] n536 AOI22X1TS
XU551 n234 n41 requesterAddressIn_SOUTH[0] n225 requesterAddressIn_EAST[0] n241
+ OAI221XLTS
XU552 n1362 n244 n829 n235 n234 OAI211XLTS
XU553 n238 requesterAddressIn_WEST[1] FE_DBTN176_n498
+ requesterAddressBuffer[1][1] n536 AOI22X1TS
XU554 n237 n41 requesterAddressIn_SOUTH[1] n225 requesterAddressIn_EAST[1] n241
+ OAI221XLTS
XU555 n1361 n244 n828 n238 n237 OAI211XLTS
XU556 n243 requesterAddressIn_WEST[2] FE_DBTN176_n498
+ requesterAddressBuffer[1][2] n536 AOI22X1TS
XU557 n242 n41 requesterAddressIn_SOUTH[2] n225 requesterAddressIn_EAST[2] n241
+ OAI221XLTS
XU558 n1360 n244 n827 n243 n242 OAI211XLTS
XU561 n245 addressToWriteBuffer[6][2] n536 addressToWriteBuffer[5][2] n250
+ FE_DBTN173_n254 addressToWriteBuffer[4][2] AOI222XLTS
XU562 n1312 n245 INVX2TS
XU564 n246 addressToWriteBuffer[6][3] n536 addressToWriteBuffer[5][3] n250
+ FE_DBTN173_n254 addressToWriteBuffer[4][3] AOI222XLTS
XU565 n1311 n246 INVX2TS
XU567 n247 addressToWriteBuffer[6][5] n536 addressToWriteBuffer[5][5] n250
+ FE_DBTN173_n254 addressToWriteBuffer[4][5] AOI222XLTS
XU568 n1309 n247 INVX2TS
XU572 n249 addressToWriteBuffer[6][4] n536 addressToWriteBuffer[5][4] n250
+ FE_DBTN173_n254 addressToWriteBuffer[4][4] AOI222XLTS
XU573 n1310 n249 INVX2TS
XU576 n251 addressToWriteBuffer[6][1] n536 addressToWriteBuffer[5][1] n250
+ FE_DBTN173_n254 addressToWriteBuffer[4][1] AOI222XLTS
XU577 n1313 n251 INVX2TS
XU579 n253 addressToWriteBuffer[6][0] n536 addressToWriteBuffer[5][0] n250
+ FE_DBTN173_n254 addressToWriteBuffer[4][0] AOI222XLTS
XU580 n1314 n253 INVX2TS
XU585 n255 dataToWriteBuffer[6][4] n536 dataToWriteBuffer[5][4] n250
+ FE_DBTN173_n254 dataToWriteBuffer[4][4] AOI222XLTS
XU586 n1239 n255 INVX2TS
XU587 n256 dataToWriteBuffer[6][5] n536 dataToWriteBuffer[5][5] n250
+ FE_DBTN173_n254 dataToWriteBuffer[4][5] AOI222XLTS
XU588 n1238 n256 INVX2TS
XU590 n257 dataToWriteBuffer[6][1] n536 dataToWriteBuffer[5][1] n250
+ FE_DBTN173_n254 dataToWriteBuffer[4][1] AOI222XLTS
XU591 n1242 n257 INVX2TS
XU593 n259 dataToWriteBuffer[6][3] n536 dataToWriteBuffer[5][3] n250
+ FE_DBTN173_n254 dataToWriteBuffer[4][3] AOI222XLTS
XU594 n1240 n259 INVX2TS
XU595 n260 dataToWriteBuffer[6][2] n536 dataToWriteBuffer[5][2] n250
+ FE_DBTN173_n254 dataToWriteBuffer[4][2] AOI222XLTS
XU596 n1241 n260 INVX2TS
XU600 n264 addressToWriteBuffer[6][6] n536 addressToWriteBuffer[5][6] n250
+ FE_DBTN173_n254 addressToWriteBuffer[4][6] AOI222XLTS
XU601 n1308 n264 INVX2TS
XU602 n267 dataToWriteBuffer[6][0] n536 dataToWriteBuffer[5][0] n250
+ FE_DBTN173_n254 dataToWriteBuffer[4][0] AOI222XLTS
XU603 n1243 n267 INVX2TS
XU606 n269 addressToWriteBuffer[5][6] n536 FE_DBTN173_n254
+ addressToWriteBuffer[3][6] n250 addressToWriteBuffer[4][6] AOI222XLTS
XU607 n1316 n269 INVX2TS
XU610 n270 addressToWriteBuffer[5][1] n536 FE_DBTN173_n254
+ addressToWriteBuffer[3][1] n250 addressToWriteBuffer[4][1] AOI222XLTS
XU611 n1321 n270 INVX2TS
XU612 n271 addressToWriteBuffer[5][2] n536 FE_DBTN173_n254
+ addressToWriteBuffer[3][2] n250 addressToWriteBuffer[4][2] AOI222XLTS
XU613 n1320 n271 INVX2TS
XU614 n273 addressToWriteBuffer[5][0] n536 FE_DBTN173_n254
+ addressToWriteBuffer[3][0] n250 addressToWriteBuffer[4][0] AOI222XLTS
XU615 n1322 n273 INVX2TS
XU617 n274 addressToWriteBuffer[5][7] n536 FE_DBTN173_n254
+ addressToWriteBuffer[3][7] n250 addressToWriteBuffer[4][7] AOI222XLTS
XU618 n1315 n274 INVX2TS
XU619 n275 addressToWriteBuffer[5][4] n536 FE_DBTN173_n254
+ addressToWriteBuffer[3][4] n250 addressToWriteBuffer[4][4] AOI222XLTS
XU620 n1318 n275 INVX2TS
XU622 n277 dataToWriteBuffer[5][0] n536 FE_DBTN173_n254 dataToWriteBuffer[3][0]
+ n250 dataToWriteBuffer[4][0] AOI222XLTS
XU623 n1249 n277 INVX2TS
XU625 n279 dataToWriteBuffer[5][5] n536 FE_DBTN173_n254 dataToWriteBuffer[3][5]
+ n250 dataToWriteBuffer[4][5] AOI222XLTS
XU626 n1244 n279 INVX2TS
XU630 n281 FE_DBTN173_n254 dataToWriteBuffer[0][4] dataToWriteBuffer[2][4] n536
+ dataToWriteBuffer[1][4] n250 AOI222XLTS
XU631 n1263 n281 INVX2TS
XU633 n282 FE_DBTN173_n254 dataToWriteBuffer[0][3] dataToWriteBuffer[2][3] n536
+ dataToWriteBuffer[1][3] n250 AOI222XLTS
XU634 n1264 n282 INVX2TS
XU635 n283 FE_DBTN173_n254 dataToWriteBuffer[0][0] dataToWriteBuffer[2][0] n536
+ dataToWriteBuffer[1][0] n250 AOI222XLTS
XU636 n1267 n283 INVX2TS
XU637 n286 FE_DBTN173_n254 dataToWriteBuffer[0][1] dataToWriteBuffer[2][1] n536
+ dataToWriteBuffer[1][1] n250 AOI222XLTS
XU638 n1266 n286 INVX2TS
XU641 n289 dataToWriteBuffer[5][1] n536 FE_DBTN173_n254 dataToWriteBuffer[3][1]
+ n250 dataToWriteBuffer[4][1] AOI222XLTS
XU642 n1248 n289 INVX2TS
XU643 n290 dataToWriteBuffer[5][3] n536 FE_DBTN173_n254 dataToWriteBuffer[3][3]
+ n250 dataToWriteBuffer[4][3] AOI222XLTS
XU644 n1246 n290 INVX2TS
XU645 n292 dataToWriteBuffer[5][4] n536 FE_DBTN173_n254 dataToWriteBuffer[3][4]
+ n250 dataToWriteBuffer[4][4] AOI222XLTS
XU646 n1245 n292 INVX2TS
XU647 n295 dataToWriteBuffer[5][2] n536 FE_DBTN173_n254 dataToWriteBuffer[3][2]
+ n250 dataToWriteBuffer[4][2] AOI222XLTS
XU648 n1247 n295 INVX2TS
XU649 n298 FE_DBTN173_n254 requesterPortBuffer[3][0] n536
+ requesterPortBuffer[5][0] n250 requesterPortBuffer[4][0] AOI222XLTS
XU650 n1277 n298 INVX2TS
XU651 n300 addressToWriteBuffer[6][7] n536 addressToWriteBuffer[5][7] n250
+ FE_DBTN173_n254 addressToWriteBuffer[4][7] AOI222XLTS
XU652 n1307 n300 INVX2TS
XU653 n302 addressToWriteBuffer[5][3] n536 FE_DBTN173_n254
+ addressToWriteBuffer[3][3] n250 addressToWriteBuffer[4][3] AOI222XLTS
XU654 n1319 n302 INVX2TS
XU655 n306 addressToWriteBuffer[5][5] n536 FE_DBTN173_n254
+ addressToWriteBuffer[3][5] n250 addressToWriteBuffer[4][5] AOI222XLTS
XU656 n1317 n306 INVX2TS
XU660 n308 FE_DBTN173_n254 addressToWriteBuffer[0][2]
+ addressToWriteBuffer[2][2] n536 addressToWriteBuffer[1][2] n250 AOI222XLTS
XU661 n1344 n308 INVX2TS
XU663 n309 FE_DBTN173_n254 addressToWriteBuffer[0][0]
+ addressToWriteBuffer[2][0] n536 addressToWriteBuffer[1][0] n250 AOI222XLTS
XU664 n1346 n309 INVX2TS
XU666 n311 FE_DBTN173_n254 dataToWriteBuffer[0][5] dataToWriteBuffer[2][5] n536
+ dataToWriteBuffer[1][5] n250 AOI222XLTS
XU667 n1262 n311 INVX2TS
XU668 n313 FE_DBTN173_n254 requesterPortBuffer[0][1] n536
+ requesterPortBuffer[2][1] requesterPortBuffer[1][1] n250 AOI222XLTS
XU669 n1282 n313 INVX2TS
XU671 n314 FE_DBTN173_n254 addressToWriteBuffer[0][7]
+ addressToWriteBuffer[2][7] n536 addressToWriteBuffer[1][7] n250 AOI222XLTS
XU672 n1339 n314 INVX2TS
XU673 n315 FE_DBTN173_n254 addressToWriteBuffer[0][1]
+ addressToWriteBuffer[2][1] n536 addressToWriteBuffer[1][1] n250 AOI222XLTS
XU674 n1345 n315 INVX2TS
XU675 n318 FE_DBTN173_n254 requesterPortBuffer[0][0] n536
+ requesterPortBuffer[2][0] requesterPortBuffer[1][0] n250 AOI222XLTS
XU676 n1363 n318 INVX2TS
XU678 n320 FE_DBTN173_n254 addressToWriteBuffer[0][5]
+ addressToWriteBuffer[2][5] n536 addressToWriteBuffer[1][5] n250 AOI222XLTS
XU679 n1341 n320 INVX2TS
XU680 n323 FE_DBTN173_n254 addressToWriteBuffer[0][3]
+ addressToWriteBuffer[2][3] n536 addressToWriteBuffer[1][3] n250 AOI222XLTS
XU681 n1343 n323 INVX2TS
XU682 n327 FE_DBTN173_n254 dataToWriteBuffer[0][2] dataToWriteBuffer[2][2] n536
+ dataToWriteBuffer[1][2] n250 AOI222XLTS
XU683 n1265 n327 INVX2TS
XU684 n328 FE_DBTN173_n254 addressToWriteBuffer[0][6]
+ addressToWriteBuffer[2][6] n536 addressToWriteBuffer[1][6] n250 AOI222XLTS
XU685 n1340 n328 INVX2TS
XU686 n332 FE_DBTN173_n254 addressToWriteBuffer[0][4]
+ addressToWriteBuffer[2][4] n536 addressToWriteBuffer[1][4] n250 AOI222XLTS
XU687 n1342 n332 INVX2TS
XU688 n437 n18 n333 n515 FE_DBTN184_n18 OAI22X1TS
XU689 n336 n437 INVX2TS
XU690 n639 n336 n40 NOR2XLTS
XU691 n647 n39 n436 reset AOI21X1TS
XU692 n334 n647 INVX2TS
XU693 n1211 n336 n40 n639 n334 AOI211XLTS
XU695 n349 n341 n340 FE_DBTN187_n13 NAND3X1TS
XU696 n351 n343 n342 NAND2X1TS
XU697 n345 n581 n512 n36 reset AOI211XLTS
XU700 n347 n346 n793 NAND2BX1TS
XU701 n367 n35 n353 n348 n347 OR4X2TS
XU703 n350 n349 n793 NAND2BX1TS
XU709 n356 n346 addressToWriteBuffer[5][0] cacheAddressIn_EAST[0] n352
+ AOI22X1TS
XU713 n355 FE_DBTN181_n57 addressToWriteBuffer[6][0] cacheAddressIn_SOUTH[0]
+ n354 AOI22X1TS
XU714 n358 n357 n350 n356 n355 OAI211XLTS
XU717 n360 n346 addressToWriteBuffer[5][6] n352 cacheAddressIn_EAST[6]
+ AOI22X1TS
XU719 n359 FE_DBTN181_n57 addressToWriteBuffer[6][6] n354
+ cacheAddressIn_SOUTH[6] AOI22X1TS
XU720 n362 n350 n361 n360 n359 OAI211XLTS
XU723 n364 n346 addressToWriteBuffer[5][5] n352 cacheAddressIn_EAST[5]
+ AOI22X1TS
XU725 n363 FE_DBTN181_n57 addressToWriteBuffer[6][5] n354
+ cacheAddressIn_SOUTH[5] AOI22X1TS
XU726 n366 n350 n365 n364 n363 OAI211XLTS
XU730 n371 n346 addressToWriteBuffer[5][4] n352 cacheAddressIn_EAST[4]
+ AOI22X1TS
XU731 n370 FE_DBTN181_n57 addressToWriteBuffer[6][4] n354
+ cacheAddressIn_SOUTH[4] AOI22X1TS
XU732 n373 n350 n372 n371 n370 OAI211XLTS
XU733 n375 n346 addressToWriteBuffer[5][7] n352 cacheAddressIn_EAST[7]
+ AOI22X1TS
XU734 n374 FE_DBTN181_n57 addressToWriteBuffer[6][7] n354
+ cacheAddressIn_SOUTH[7] AOI22X1TS
XU735 n377 n350 n376 n375 n374 OAI211XLTS
XU736 n379 n346 dataToWriteBuffer[5][1] n352 dataIn_EAST[1] AOI22X1TS
XU737 n378 FE_DBTN181_n57 dataToWriteBuffer[6][1] n354 dataIn_SOUTH[1]
+ AOI22X1TS
XU738 n381 n350 n380 n379 n378 OAI211XLTS
XU740 n385 n346 addressToWriteBuffer[5][2] n352 cacheAddressIn_EAST[2]
+ AOI22X1TS
XU742 n384 FE_DBTN181_n57 addressToWriteBuffer[6][2] n354
+ cacheAddressIn_SOUTH[2] AOI22X1TS
XU743 n389 n346 dataToWriteBuffer[5][4] n352 dataIn_EAST[4] AOI22X1TS
XU744 n388 FE_DBTN181_n57 dataToWriteBuffer[6][4] n354 dataIn_SOUTH[4]
+ AOI22X1TS
XU745 n394 n346 addressToWriteBuffer[5][1] n352 cacheAddressIn_EAST[1]
+ AOI22X1TS
XU746 n393 FE_DBTN181_n57 addressToWriteBuffer[6][1] n354
+ cacheAddressIn_SOUTH[1] AOI22X1TS
XU747 n400 n346 dataToWriteBuffer[5][0] n352 dataIn_EAST[0] AOI22X1TS
XU748 n399 FE_DBTN181_n57 dataToWriteBuffer[6][0] n354 dataIn_SOUTH[0]
+ AOI22X1TS
XU749 n406 n346 dataToWriteBuffer[5][3] n352 dataIn_EAST[3] AOI22X1TS
XU750 n405 FE_DBTN181_n57 dataToWriteBuffer[6][3] n354 dataIn_SOUTH[3]
+ AOI22X1TS
XU751 n411 n346 dataToWriteBuffer[5][2] n352 dataIn_EAST[2] AOI22X1TS
XU752 n410 FE_DBTN181_n57 dataToWriteBuffer[6][2] n354 dataIn_SOUTH[2]
+ AOI22X1TS
XU753 n419 n346 dataToWriteBuffer[5][5] n352 dataIn_EAST[5] AOI22X1TS
XU754 n418 FE_DBTN181_n57 dataToWriteBuffer[6][5] n354 dataIn_SOUTH[5]
+ AOI22X1TS
XU755 n428 n346 addressToWriteBuffer[5][3] n352 cacheAddressIn_EAST[3]
+ AOI22X1TS
XU756 n427 FE_DBTN181_n57 addressToWriteBuffer[6][3] n354
+ cacheAddressIn_SOUTH[3] AOI22X1TS
XU757 n434 memWrite_EAST n433 memWrite_SOUTH n225 AOI22X1TS
XU758 n679 n133 n622 n434 n134 AOI22X1TS
XU759 n677 n436 n254 OR2X1TS
XU760 n441 n440 FE_DBTN187_n13 NOR2BX1TS
XU761 n550 n441 n254 OR2X1TS
XU763 n444 requesterPortBuffer[2][1] FE_DBTN171_n550 requesterPortBuffer[3][1]
+ n250 AOI22X1TS
XU764 n443 n441 n793 NAND2X1TS
XU766 n449 requesterPortBuffer[3][0] n36 n441 AOI21X1TS
XU770 n448 n536 requesterPortBuffer[4][0] requesterPortBuffer[2][0]
+ FE_DBTN171_n550 AOI22X1TS
XU771 n454 dataIn_WEST[2] n56 n53 dataToWriteBuffer[1][2] AOI22X1TS
XU772 n453 FE_DBTN181_n57 dataToWriteBuffer[2][2] n59 dataToWriteBuffer[3][2]
+ AOI22X1TS
XU774 n460 cacheAddressIn_WEST[5] n56 n53 addressToWriteBuffer[1][5] AOI22X1TS
XU776 n459 FE_DBTN181_n57 addressToWriteBuffer[2][5] n59
+ addressToWriteBuffer[3][5] AOI22X1TS
XU777 n464 cacheAddressIn_WEST[6] n56 n53 addressToWriteBuffer[1][6] AOI22X1TS
XU778 n463 FE_DBTN181_n57 addressToWriteBuffer[2][6] n59
+ addressToWriteBuffer[3][6] AOI22X1TS
XU779 n467 dataIn_WEST[0] n56 n53 dataToWriteBuffer[1][0] AOI22X1TS
XU780 n466 FE_DBTN181_n57 dataToWriteBuffer[2][0] n59 dataToWriteBuffer[3][0]
+ AOI22X1TS
XU781 n471 cacheAddressIn_WEST[1] n56 n53 addressToWriteBuffer[1][1] AOI22X1TS
XU782 n470 FE_DBTN181_n57 addressToWriteBuffer[2][1] n59
+ addressToWriteBuffer[3][1] AOI22X1TS
XU783 n478 cacheAddressIn_WEST[2] n56 n53 addressToWriteBuffer[1][2] AOI22X1TS
XU784 n477 FE_DBTN181_n57 addressToWriteBuffer[2][2] n59
+ addressToWriteBuffer[3][2] AOI22X1TS
XU785 n486 dataIn_WEST[4] n56 n53 dataToWriteBuffer[1][4] AOI22X1TS
XU786 n485 FE_DBTN181_n57 dataToWriteBuffer[2][4] n59 dataToWriteBuffer[3][4]
+ AOI22X1TS
XU787 n493 dataIn_WEST[5] n56 n53 dataToWriteBuffer[1][5] AOI22X1TS
XU788 n492 FE_DBTN181_n57 dataToWriteBuffer[2][5] n59 dataToWriteBuffer[3][5]
+ AOI22X1TS
XU789 n496 n536 requesterPortBuffer[1][1] prevRequesterPort_B[1] n497 AOI22X1TS
XU790 n499 n536 requesterPortBuffer[1][0] n7 n497 AOI22X1TS
XU791 n825 FE_DBTN173_n254 requesterPortBuffer[4][0] n250
+ requesterPortBuffer[5][0] AO22XLTS
XU792 N5340 FE_DBTN183_n26 prevMemRead_A FE_DBTN188_n3 prevMemRead_B AO22XLTS
XU793 N5377 n192 cacheDataOut_A[4] FE_DBTN174_n205 cacheDataOut_B[4] AO22X1TS
XU794 FE_PHN229_N5378 n192 cacheDataOut_A[5] FE_DBTN174_n205 cacheDataOut_B[5]
+ AO22X1TS
XU795 n702 n514 n512 n677 OR3X1TS
XU797 n661 n39 reset NOR2XLTS
XU799 n518 n32 n514 NAND2X1TS
XU800 n684 n33 n653 NAND2X1TS
XU801 n520 n793 n684 NAND2X1TS
XU802 n522 requesterPortBuffer[0][0] n661 n521 n520 AOI22X1TS
XU805 n525 requesterPortBuffer[0][1] n661 n4 n520 AOI22X1TS
XU806 n526 FE_DBTN173_n254 requesterAddressBuffer[0][0]
+ requesterAddressIn_SOUTH[0] n250 AOI22X1TS
XU807 n1354 requesterAddressIn_EAST[0] n536 n526 OAI2BB1X1TS
XU808 n527 FE_DBTN173_n254 requesterAddressBuffer[0][1]
+ requesterAddressIn_SOUTH[1] n250 AOI22X1TS
XU809 n1353 requesterAddressIn_EAST[1] n536 n527 OAI2BB1X1TS
XU810 n531 FE_DBTN173_n254 requesterAddressBuffer[0][2]
+ requesterAddressIn_SOUTH[2] n250 AOI22X1TS
XU811 n1352 requesterAddressIn_EAST[2] n536 n531 OAI2BB1X1TS
XU812 n535 FE_DBTN173_n254 requesterAddressBuffer[0][3]
+ requesterAddressIn_SOUTH[3] n250 AOI22X1TS
XU813 n1351 requesterAddressIn_EAST[3] n536 n535 OAI2BB1X1TS
XU814 n545 n35 n54 NAND2X1TS
XU815 n541 requesterAddressIn_EAST[0] n544 requesterAddressIn_WEST[0] n545
+ AOI22X1TS
XU816 n612 n609 n793 n575 NAND3X1TS
XU817 n574 n793 n612 NAND2X1TS
XU819 n1350 FE_DBTN170_n612 requesterAddressBuffer[1][0] n541 n574 OAI2BB2XLTS
XU820 n542 requesterAddressIn_WEST[1] n545 requesterAddressIn_EAST[1] n544
+ AOI22X1TS
XU822 n1349 FE_DBTN170_n612 requesterAddressBuffer[1][1] n542 n574 OAI2BB2XLTS
XU823 n543 requesterAddressIn_WEST[2] n545 requesterAddressIn_EAST[2] n544
+ AOI22X1TS
XU824 n1348 FE_DBTN170_n612 requesterAddressBuffer[1][2] n543 n574 OAI2BB2XLTS
XU825 n546 requesterAddressIn_WEST[3] n545 requesterAddressIn_EAST[3] n544
+ AOI22X1TS
XU826 n1347 FE_DBTN170_n612 requesterAddressBuffer[1][3] n546 n574 OAI2BB2XLTS
XU828 n549 addressToWriteBuffer[3][0] n250 n536 addressToWriteBuffer[4][0]
+ AOI22X1TS
XU831 n548 cacheAddressIn_WEST[0] n547 addressToWriteBuffer[2][0]
+ FE_DBTN171_n550 AOI22X1TS
XU832 n1330 n549 n548 NAND2X1TS
XU834 n552 addressToWriteBuffer[3][1] n250 n536 addressToWriteBuffer[4][1]
+ AOI22X1TS
XU837 n551 cacheAddressIn_WEST[1] n547 addressToWriteBuffer[2][1]
+ FE_DBTN171_n550 AOI22X1TS
XU838 n1329 n552 n551 NAND2X1TS
XU839 n554 addressToWriteBuffer[3][2] n250 n536 addressToWriteBuffer[4][2]
+ AOI22X1TS
XU841 n553 cacheAddressIn_WEST[2] n547 addressToWriteBuffer[2][2]
+ FE_DBTN171_n550 AOI22X1TS
XU842 n1328 n554 n553 NAND2X1TS
XU844 n559 addressToWriteBuffer[3][3] n250 n536 addressToWriteBuffer[4][3]
+ AOI22X1TS
XU845 n558 cacheAddressIn_WEST[3] n547 addressToWriteBuffer[2][3]
+ FE_DBTN171_n550 AOI22X1TS
XU846 n1327 n559 n558 NAND2X1TS
XU848 n562 addressToWriteBuffer[3][4] n250 n536 addressToWriteBuffer[4][4]
+ AOI22X1TS
XU850 n561 cacheAddressIn_WEST[4] n547 addressToWriteBuffer[2][4]
+ FE_DBTN171_n550 AOI22X1TS
XU851 n1326 n562 n561 NAND2X1TS
XU853 n565 addressToWriteBuffer[3][5] n250 n536 addressToWriteBuffer[4][5]
+ AOI22X1TS
XU854 n564 cacheAddressIn_WEST[5] n547 addressToWriteBuffer[2][5]
+ FE_DBTN171_n550 AOI22X1TS
XU855 n1325 n565 n564 NAND2X1TS
XU856 n567 addressToWriteBuffer[3][6] n250 n536 addressToWriteBuffer[4][6]
+ AOI22X1TS
XU857 n566 cacheAddressIn_WEST[6] n547 addressToWriteBuffer[2][6]
+ FE_DBTN171_n550 AOI22X1TS
XU858 n1324 n567 n566 NAND2X1TS
XU859 n569 addressToWriteBuffer[3][7] n250 n536 addressToWriteBuffer[4][7]
+ AOI22X1TS
XU860 n568 cacheAddressIn_WEST[7] n547 addressToWriteBuffer[2][7]
+ FE_DBTN171_n550 AOI22X1TS
XU861 n1323 n569 n568 NAND2X1TS
XU863 n571 requesterPortBuffer[2][0] n36 requesterPortBuffer[3][0]
+ FE_DBTN182_n35 AOI22X1TS
XU864 n572 n571 n54 n574 AOI21X1TS
XU865 n576 requesterPortBuffer[2][1] n36 requesterPortBuffer[3][1]
+ FE_DBTN182_n35 AOI22X1TS
XU866 n577 n576 n575 n54 n574 AOI31XLTS
XU867 n583 n629 requesterPortBuffer[5][0] NAND2X1TS
XU868 n582 n32 n581 n536 n579 NAND4XLTS
XU869 n585 dataToWriteBuffer[3][0] n250 n536 dataToWriteBuffer[4][0] AOI22X1TS
XU870 n584 dataIn_WEST[0] n547 dataToWriteBuffer[2][0] FE_DBTN171_n550
+ AOI22X1TS
XU871 n1255 n585 n584 NAND2X1TS
XU872 n589 dataToWriteBuffer[3][1] n250 n536 dataToWriteBuffer[4][1] AOI22X1TS
XU873 n588 dataIn_WEST[1] n547 dataToWriteBuffer[2][1] FE_DBTN171_n550
+ AOI22X1TS
XU874 n1254 n589 n588 NAND2X1TS
XU875 n594 dataToWriteBuffer[3][2] n250 n536 dataToWriteBuffer[4][2] AOI22X1TS
XU876 n593 dataIn_WEST[2] n547 dataToWriteBuffer[2][2] FE_DBTN171_n550
+ AOI22X1TS
XU877 n1253 n594 n593 NAND2X1TS
XU878 n598 dataToWriteBuffer[3][3] n250 n536 dataToWriteBuffer[4][3] AOI22X1TS
XU879 n597 dataIn_WEST[3] n547 dataToWriteBuffer[2][3] FE_DBTN171_n550
+ AOI22X1TS
XU880 n1252 n598 n597 NAND2X1TS
XU881 n602 dataToWriteBuffer[3][4] n250 n536 dataToWriteBuffer[4][4] AOI22X1TS
XU882 n601 dataIn_WEST[4] n547 dataToWriteBuffer[2][4] FE_DBTN171_n550
+ AOI22X1TS
XU883 n1251 n602 n601 NAND2X1TS
XU884 n608 dataToWriteBuffer[3][5] n250 n536 dataToWriteBuffer[4][5] AOI22X1TS
XU885 n607 dataIn_WEST[5] n547 dataToWriteBuffer[2][5] FE_DBTN171_n550
+ AOI22X1TS
XU886 n1250 n608 n607 NAND2X1TS
XU888 n610 n609 memWrite_EAST isWrite[3] FE_DBTN182_n35 AOI22X1TS
XU889 n614 n36 isWrite[2] n611 AOI21X1TS
XU890 n1218 n614 n574 n612 n832 OAI22X1TS
XU892 n615 FE_DBTN182_n35 isWrite[4] isWrite[3] n36 memWrite_WEST n441
+ AOI222XLTS
XU893 n1217 FE_DBTN171_n550 isWrite[2] reset n615 OAI2BB2XLTS
XU895 n617 isWrite[4] n36 isWrite[5] FE_DBTN182_n35 AOI22X1TS
XU897 n1216 isWrite[3] FE_DBTN173_n254 reset n617 OAI2BB2XLTS
XU899 n621 isWrite[5] n36 NAND2X1TS
XU900 n1215 isWrite[4] FE_DBTN173_n254 reset n621 OAI2BB2XLTS
XU902 n624 n623 INVX2TS
XU903 n632 memWrite_WEST n624 NAND2X1TS
XU904 n630 memWrite_EAST n627 n536 FE_DBTN184_n18 OAI211XLTS
XU905 n1214 n632 n631 n630 n629 n833 AOI32X1TS
XU907 n635 FE_DBTN184_n18 n640 n133 FE_DBTN185_n16 OAI22X1TS
XU908 n637 n639 n635 XNOR2X1TS
XU909 n636 n646 n637 n647 OAI21XLTS
XU910 n1210 n646 n637 n636 AOI21X1TS
XU911 n643 n644 n646 n639 OA21XLTS
XU912 n650 n646 n644 n643 n642 AOI211XLTS
XU913 n645 N742 n830 OR2X1TS
XU914 n649 n20 n646 n645 OAI21XLTS
XU915 n1209 n650 n649 n648 AOI21X1TS
XU918 n657 requesterAddressIn_WEST[0] FE_DBTN169_n651 n815 n520 AOI22X1TS
XU920 n656 requesterAddressIn_EAST[0] n524 n661 requesterAddressBuffer[0][0]
+ AOI22X1TS
XU923 n655 FE_DBTN167_n702 requesterAddressIn_SOUTH[0] n654
+ requesterAddressIn_NORTH[0] AOI22X1TS
XU925 n660 requesterAddressIn_WEST[1] FE_DBTN169_n651 n810 n520 AOI22X1TS
XU927 n659 requesterAddressIn_EAST[1] n524 n661 requesterAddressBuffer[0][1]
+ AOI22X1TS
XU930 n658 FE_DBTN167_n702 requesterAddressIn_SOUTH[1] n654
+ requesterAddressIn_NORTH[1] AOI22X1TS
XU932 n664 requesterAddressIn_WEST[2] FE_DBTN169_n651 n807 n520 AOI22X1TS
XU933 n663 requesterAddressIn_EAST[2] n524 n661 requesterAddressBuffer[0][2]
+ AOI22X1TS
XU936 n662 FE_DBTN167_n702 requesterAddressIn_SOUTH[2] n654
+ requesterAddressIn_NORTH[2] AOI22X1TS
XU937 n670 requesterAddressIn_WEST[3] FE_DBTN169_n651 n801 n520 AOI22X1TS
XU939 n669 requesterAddressIn_EAST[3] n524 n661 requesterAddressBuffer[0][3]
+ AOI22X1TS
XU941 n668 FE_DBTN167_n702 requesterAddressIn_SOUTH[3] n654
+ requesterAddressIn_NORTH[3] AOI22X1TS
XU942 n683 n46 n793 NAND2X1TS
XU943 n675 memWrite_WEST n673 memWrite_EAST n672 AOI22X1TS
XU944 n718 memRead_NORTH n676 n675 n674 OAI211XLTS
XU945 n1203 isWrite[0] n683 n718 n677 OAI22X1TS
XU946 n680 n39 isWrite[1] n46 n679 n793 OAI221XLTS
XU950 n689 FE_DBTN168_n683 dataToWriteBuffer[0][0] FE_DBTN186_n15
+ cacheDataIn_A[0] AOI22X1TS
XU951 n688 dataIn_WEST[0] FE_DBTN169_n651 dataIn_EAST[0] n524 AOI22X1TS
XU952 n687 dataIn_NORTH[0] n654 dataIn_SOUTH[0] FE_DBTN167_n702 AOI22X1TS
XU954 n694 FE_DBTN168_n683 dataToWriteBuffer[0][1] FE_DBTN186_n15
+ cacheDataIn_A[1] AOI22X1TS
XU955 n693 dataIn_WEST[1] FE_DBTN169_n651 dataIn_EAST[1] n524 AOI22X1TS
XU956 n692 dataIn_NORTH[1] n654 dataIn_SOUTH[1] FE_DBTN167_n702 AOI22X1TS
XU958 n698 FE_DBTN168_n683 dataToWriteBuffer[0][2] FE_DBTN186_n15
+ cacheDataIn_A[2] AOI22X1TS
XU959 n697 dataIn_WEST[2] FE_DBTN169_n651 dataIn_EAST[2] n524 AOI22X1TS
XU960 n696 dataIn_NORTH[2] n654 dataIn_SOUTH[2] FE_DBTN167_n702 AOI22X1TS
XU962 n705 FE_DBTN168_n683 dataToWriteBuffer[0][3] FE_DBTN186_n15
+ cacheDataIn_A[3] AOI22X1TS
XU963 n704 dataIn_WEST[3] FE_DBTN169_n651 dataIn_EAST[3] n524 AOI22X1TS
XU965 n703 dataIn_NORTH[3] n654 dataIn_SOUTH[3] FE_DBTN167_n702 AOI22X1TS
XU967 n710 FE_DBTN168_n683 dataToWriteBuffer[0][4] FE_DBTN186_n15
+ cacheDataIn_A[4] AOI22X1TS
XU969 n709 dataIn_WEST[4] FE_DBTN169_n651 dataIn_EAST[4] n524 AOI22X1TS
XU970 n708 dataIn_NORTH[4] n654 dataIn_SOUTH[4] FE_DBTN167_n702 AOI22X1TS
XU972 n716 FE_DBTN168_n683 dataToWriteBuffer[0][5] FE_DBTN186_n15
+ cacheDataIn_A[5] AOI22X1TS
XU973 n715 dataIn_WEST[5] FE_DBTN169_n651 dataIn_EAST[5] n524 AOI22X1TS
XU974 n714 dataIn_NORTH[5] n654 dataIn_SOUTH[5] FE_DBTN167_n702 AOI22X1TS
XU975 n719 n39 isWrite[0] n46 n718 n793 OAI221XLTS
XU976 n720 n719 INVX2TS
XU978 n1181 FE_DBTN186_n15 memWrite_A FE_DBTN186_n15 n720 OAI2BB2XLTS
XU979 n725 FE_DBTN168_n683 addressToWriteBuffer[0][7] FE_DBTN186_n15
+ cacheAddressIn_A[7] AOI22X1TS
XU980 n724 cacheAddressIn_WEST[7] FE_DBTN169_n651 cacheAddressIn_EAST[7] n524
+ AOI22X1TS
XU981 n723 cacheAddressIn_NORTH[7] n654 cacheAddressIn_SOUTH[7] FE_DBTN167_n702
+ AOI22X1TS
XU982 n730 FE_DBTN168_n683 addressToWriteBuffer[0][6] FE_DBTN186_n15
+ cacheAddressIn_A[6] AOI22X1TS
XU983 n729 cacheAddressIn_WEST[6] FE_DBTN169_n651 cacheAddressIn_EAST[6] n524
+ AOI22X1TS
XU984 n728 cacheAddressIn_NORTH[6] n654 cacheAddressIn_SOUTH[6] FE_DBTN167_n702
+ AOI22X1TS
XU985 n736 FE_DBTN168_n683 addressToWriteBuffer[0][5] FE_DBTN186_n15
+ cacheAddressIn_A[5] AOI22X1TS
XU986 n735 cacheAddressIn_WEST[5] FE_DBTN169_n651 cacheAddressIn_EAST[5] n524
+ AOI22X1TS
XU987 n734 cacheAddressIn_NORTH[5] n654 cacheAddressIn_SOUTH[5] FE_DBTN167_n702
+ AOI22X1TS
XU988 n742 FE_DBTN168_n683 addressToWriteBuffer[0][4] FE_DBTN186_n15
+ cacheAddressIn_A[4] AOI22X1TS
XU989 n741 cacheAddressIn_WEST[4] FE_DBTN169_n651 cacheAddressIn_EAST[4] n524
+ AOI22X1TS
XU990 n740 cacheAddressIn_NORTH[4] n654 cacheAddressIn_SOUTH[4] FE_DBTN167_n702
+ AOI22X1TS
XU991 n750 FE_DBTN168_n683 addressToWriteBuffer[0][3] FE_DBTN186_n15
+ cacheAddressIn_A[3] AOI22X1TS
XU992 n749 cacheAddressIn_WEST[3] FE_DBTN169_n651 cacheAddressIn_EAST[3] n524
+ AOI22X1TS
XU993 n748 cacheAddressIn_NORTH[3] n654 cacheAddressIn_SOUTH[3] FE_DBTN167_n702
+ AOI22X1TS
XU994 n758 FE_DBTN168_n683 addressToWriteBuffer[0][2] FE_DBTN186_n15
+ cacheAddressIn_A[2] AOI22X1TS
XU995 n757 cacheAddressIn_WEST[2] FE_DBTN169_n651 cacheAddressIn_EAST[2] n524
+ AOI22X1TS
XU996 n756 cacheAddressIn_NORTH[2] n654 cacheAddressIn_SOUTH[2] FE_DBTN167_n702
+ AOI22X1TS
XU997 n766 FE_DBTN168_n683 addressToWriteBuffer[0][1] FE_DBTN186_n15
+ cacheAddressIn_A[1] AOI22X1TS
XU998 n765 cacheAddressIn_WEST[1] FE_DBTN169_n651 cacheAddressIn_EAST[1] n524
+ AOI22X1TS
XU999 n764 cacheAddressIn_NORTH[1] n654 cacheAddressIn_SOUTH[1] FE_DBTN167_n702
+ AOI22X1TS
XU1000 n774 FE_DBTN168_n683 addressToWriteBuffer[0][0] FE_DBTN186_n15
+ cacheAddressIn_A[0] AOI22X1TS
XU1001 n773 cacheAddressIn_WEST[0] FE_DBTN169_n651 cacheAddressIn_EAST[0] n524
+ AOI22X1TS
XU1002 n772 cacheAddressIn_NORTH[0] n654 cacheAddressIn_SOUTH[0]
+ FE_DBTN167_n702 AOI22X1TS
XU1003 n777 n801 FE_DBTN183_n26 prevRequesterAddress_B[3] FE_DBTN188_n3
+ AOI22X1TS
XU1004 n786 reset FE_DBTN183_n26 FE_DBTN188_n3 NOR3XLTS
XU1005 n1171 requesterAddressOut_WEST[3] n786 reset n777 OAI2BB2XLTS
XU1006 n780 n807 FE_DBTN183_n26 prevRequesterAddress_B[2] FE_DBTN188_n3
+ AOI22X1TS
XU1007 n1170 requesterAddressOut_WEST[2] n786 reset n780 OAI2BB2XLTS
XU1008 n783 n810 FE_DBTN183_n26 prevRequesterAddress_B[1] FE_DBTN188_n3
+ AOI22X1TS
XU1009 n1169 requesterAddressOut_WEST[1] n786 reset n783 OAI2BB2XLTS
XU1010 n787 n815 FE_DBTN183_n26 prevRequesterAddress_B[0] FE_DBTN188_n3
+ AOI22X1TS
XU1011 n1168 requesterAddressOut_WEST[0] n786 reset n787 OAI2BB2XLTS
XU1012 n790 prevRequesterAddress_A[3] n21 prevRequesterAddress_B[3] n23
+ AOI22X1TS
XU1013 n798 reset n21 n23 NOR3XLTS
XU1014 n1167 requesterAddressOut_EAST[3] n798 reset n790 OAI2BB2XLTS
XU1015 n792 prevRequesterAddress_A[2] n21 prevRequesterAddress_B[2] n23
+ AOI22X1TS
XU1016 n1166 requesterAddressOut_EAST[2] n798 reset n792 OAI2BB2XLTS
XU1017 n795 prevRequesterAddress_A[1] n21 prevRequesterAddress_B[1] n23
+ AOI22X1TS
XU1018 n1165 requesterAddressOut_EAST[1] n798 reset n795 OAI2BB2XLTS
XU1019 n799 prevRequesterAddress_A[0] n21 prevRequesterAddress_B[0] n23
+ AOI22X1TS
XU1020 n1164 requesterAddressOut_EAST[0] n798 reset n799 OAI2BB2XLTS
XU1021 n805 n801 n27 prevRequesterAddress_B[3] n28 AOI22X1TS
XU1022 n816 reset n27 n28 NOR3XLTS
XU1023 n1163 requesterAddressOut_SOUTH[3] n816 reset n805 OAI2BB2XLTS
XU1024 n808 n807 n27 prevRequesterAddress_B[2] n28 AOI22X1TS
XU1025 n1162 requesterAddressOut_SOUTH[2] n816 reset n808 OAI2BB2XLTS
XU1026 n811 n810 n27 prevRequesterAddress_B[1] n28 AOI22X1TS
XU1027 n1161 requesterAddressOut_SOUTH[1] n816 reset n811 OAI2BB2XLTS
XU1028 n817 n815 n27 prevRequesterAddress_B[0] n28 AOI22X1TS
XU1029 n1160 requesterAddressOut_SOUTH[0] n816 reset n817 OAI2BB2XLTS
.ENDS

.SUBCKT outputPortArbiter_0 clk reset selectBit_NORTH
+ destinationAddressIn_NORTH[11] destinationAddressIn_NORTH[10]
+ destinationAddressIn_NORTH[9] destinationAddressIn_NORTH[8]
+ destinationAddressIn_NORTH[7] destinationAddressIn_NORTH[6]
+ destinationAddressIn_NORTH[5] destinationAddressIn_NORTH[4]
+ destinationAddressIn_NORTH[3] destinationAddressIn_NORTH[2]
+ destinationAddressIn_NORTH[1] destinationAddressIn_NORTH[0]
+ requesterAddressIn_NORTH[3] requesterAddressIn_NORTH[2]
+ requesterAddressIn_NORTH[1] requesterAddressIn_NORTH[0] readIn_NORTH
+ writeIn_NORTH dataIn_NORTH[5] dataIn_NORTH[4] dataIn_NORTH[3] dataIn_NORTH[2]
+ dataIn_NORTH[1] dataIn_NORTH[0] selectBit_SOUTH
+ destinationAddressIn_SOUTH[11] destinationAddressIn_SOUTH[10]
+ destinationAddressIn_SOUTH[9] destinationAddressIn_SOUTH[8]
+ destinationAddressIn_SOUTH[7] destinationAddressIn_SOUTH[6]
+ destinationAddressIn_SOUTH[5] destinationAddressIn_SOUTH[4]
+ destinationAddressIn_SOUTH[3] destinationAddressIn_SOUTH[2]
+ destinationAddressIn_SOUTH[1] destinationAddressIn_SOUTH[0]
+ requesterAddressIn_SOUTH[3] requesterAddressIn_SOUTH[2]
+ requesterAddressIn_SOUTH[1] requesterAddressIn_SOUTH[0] readIn_SOUTH
+ writeIn_SOUTH dataIn_SOUTH[5] dataIn_SOUTH[4] dataIn_SOUTH[3] dataIn_SOUTH[2]
+ dataIn_SOUTH[1] dataIn_SOUTH[0] selectBit_EAST destinationAddressIn_EAST[11]
+ destinationAddressIn_EAST[10] destinationAddressIn_EAST[9]
+ destinationAddressIn_EAST[8] destinationAddressIn_EAST[7]
+ destinationAddressIn_EAST[6] destinationAddressIn_EAST[5]
+ destinationAddressIn_EAST[4] destinationAddressIn_EAST[3]
+ destinationAddressIn_EAST[2] destinationAddressIn_EAST[1]
+ destinationAddressIn_EAST[0] requesterAddressIn_EAST[3]
+ requesterAddressIn_EAST[2] requesterAddressIn_EAST[1]
+ requesterAddressIn_EAST[0] readIn_EAST writeIn_EAST dataIn_EAST[5]
+ dataIn_EAST[4] dataIn_EAST[3] dataIn_EAST[2] dataIn_EAST[1] dataIn_EAST[0]
+ selectBit_WEST destinationAddressIn_WEST[11] destinationAddressIn_WEST[10]
+ destinationAddressIn_WEST[9] destinationAddressIn_WEST[8]
+ destinationAddressIn_WEST[7] destinationAddressIn_WEST[6]
+ destinationAddressIn_WEST[5] destinationAddressIn_WEST[4]
+ destinationAddressIn_WEST[3] destinationAddressIn_WEST[2]
+ destinationAddressIn_WEST[1] destinationAddressIn_WEST[0]
+ requesterAddressIn_WEST[3] requesterAddressIn_WEST[2]
+ requesterAddressIn_WEST[1] requesterAddressIn_WEST[0] readIn_WEST
+ writeIn_WEST dataIn_WEST[5] dataIn_WEST[4] dataIn_WEST[3] dataIn_WEST[2]
+ dataIn_WEST[1] dataIn_WEST[0] readReady readRequesterAddress[3]
+ readRequesterAddress[2] readRequesterAddress[1] readRequesterAddress[0]
+ cacheDataOut[5] cacheDataOut[4] cacheDataOut[3] cacheDataOut[2]
+ cacheDataOut[1] cacheDataOut[0] destinationAddressOut[11]
+ destinationAddressOut[10] destinationAddressOut[9] destinationAddressOut[8]
+ destinationAddressOut[7] destinationAddressOut[6] destinationAddressOut[5]
+ destinationAddressOut[4] destinationAddressOut[3] destinationAddressOut[2]
+ destinationAddressOut[1] destinationAddressOut[0] requesterAddressOut[3]
+ requesterAddressOut[2] requesterAddressOut[1] requesterAddressOut[0] readOut
+ writeOut dataOut[5] dataOut[4] dataOut[3] dataOut[2] dataOut[1] dataOut[0]
XFE_DBTC217_readInBuffer_EAST FE_DBTN217_readInBuffer_EAST readIn_EAST INVX2TS
XFE_DBTC213_writeInBuffer_EAST FE_DBTN213_writeInBuffer_EAST writeIn_EAST
+ INVX2TS
XFE_DBTC210_destinationAddressInBuffer_EAST_11_
+ FE_DBTN210_destinationAddressInBuffer_EAST_11_ destinationAddressIn_EAST[11]
+ INVX2TS
XFE_DBTC207_destinationAddressInBuffer_EAST_10_
+ FE_DBTN207_destinationAddressInBuffer_EAST_10_ destinationAddressIn_EAST[10]
+ INVX2TS
XFE_DBTC204_destinationAddressInBuffer_EAST_9_
+ FE_DBTN204_destinationAddressInBuffer_EAST_9_ destinationAddressIn_EAST[9]
+ INVX2TS
XFE_DBTC201_destinationAddressInBuffer_EAST_8_
+ FE_DBTN201_destinationAddressInBuffer_EAST_8_ destinationAddressIn_EAST[8]
+ INVX2TS
XFE_DBTC200_destinationAddressInBuffer_EAST_7_
+ FE_DBTN200_destinationAddressInBuffer_EAST_7_ destinationAddressIn_EAST[7]
+ INVX2TS
XFE_DBTC197_destinationAddressInBuffer_EAST_6_
+ FE_DBTN197_destinationAddressInBuffer_EAST_6_ destinationAddressIn_EAST[6]
+ INVX2TS
XFE_DBTC194_destinationAddressInBuffer_EAST_5_
+ FE_DBTN194_destinationAddressInBuffer_EAST_5_ destinationAddressIn_EAST[5]
+ INVX2TS
XFE_DBTC191_destinationAddressInBuffer_EAST_4_
+ FE_DBTN191_destinationAddressInBuffer_EAST_4_ destinationAddressIn_EAST[4]
+ INVX2TS
XFE_DBTC166_n1 FE_DBTN166_n1 n1 INVX2TS
XFE_DBTC165_n2 FE_DBTN165_n2 n2 INVX2TS
XFE_DBTC164_n3 FE_DBTN164_n3 n3 INVX2TS
XFE_DBTC163_n4 FE_DBTN163_n4 n4 INVX2TS
XFE_DBTC162_n5 FE_DBTN162_n5 n5 INVX2TS
XFE_DBTC161_n6 FE_DBTN161_n6 n6 INVX2TS
XFE_DBTC160_n7 FE_DBTN160_n7 n7 INVX2TS
XFE_DBTC159_n8 FE_DBTN159_n8 n8 INVX2TS
XFE_DBTC158_n10 FE_DBTN158_n10 n10 INVX2TS
XFE_DBTC157_n11 FE_DBTN157_n11 n11 INVX2TS
XFE_DBTC156_n12 FE_DBTN156_n12 n12 INVX2TS
XFE_DBTC155_n13 FE_DBTN155_n13 n13 INVX2TS
XFE_DBTC154_n14 FE_DBTN154_n14 n14 INVX2TS
XFE_DBTC153_n57 FE_DBTN153_n57 n57 INVX2TS
XFE_DBTC152_n1547 FE_DBTN152_n1547 n1547 INVX2TS
XFE_DBTC151_n62 FE_DBTN151_n62 n62 INVX2TS
XFE_DBTC150_n1962 FE_DBTN150_n1962 n1962 INVX2TS
XFE_DBTC149_n106 FE_DBTN149_n106 n106 INVX2TS
XFE_DBTC148_n1496 FE_DBTN148_n1496 n1496 INVX2TS
XFE_DBTC147_n1397 FE_DBTN147_n1397 n1397 INVX2TS
XFE_DBTC146_n186 FE_DBTN146_n186 n186 INVX2TS
XFE_DBTC145_n202 FE_DBTN145_n202 n202 INVX2TS
XFE_DBTC144_n1362 FE_DBTN144_n1362 n1362 INVX2TS
XFE_DBTC143_n243 FE_DBTN143_n243 n243 INVX2TS
XFE_DBTC142_n250 FE_DBTN142_n250 n250 INVX2TS
XFE_DBTC141_n1460 FE_DBTN141_n1460 n1460 INVX2TS
XFE_DBTC140_n1960 FE_DBTN140_n1960 n1960 INVX2TS
XFE_DBTC139_n293 FE_DBTN139_n293 n293 INVX2TS
XFE_DBTC138_n1429 FE_DBTN138_n1429 n1429 INVX2TS
XFE_DBTC137_n1958 FE_DBTN137_n1958 n1958 INVX2TS
XFE_DBTC136_n346 FE_DBTN136_n346 n346 INVX2TS
XFE_DBTC135_n359 FE_DBTN135_n359 n359 INVX2TS
XFE_DBTC134_n1957 FE_DBTN134_n1957 n1957 INVX2TS
XFE_DBTC133_n1954 FE_DBTN133_n1954 n1954 INVX2TS
XFE_DBTC132_n418 FE_DBTN132_n418 n418 INVX2TS
XFE_DBTC131_n428 FE_DBTN131_n428 n428 INVX2TS
XFE_DBTC130_n1959 FE_DBTN130_n1959 n1959 INVX2TS
XFE_DBTC129_n678 FE_DBTN129_n678 n678 INVX2TS
XFE_DBTC128_n1961 FE_DBTN128_n1961 n1961 INVX2TS
XFE_DBTC127_n1953 FE_DBTN127_n1953 n1953 INVX2TS
XFE_DBTC126_n1952 FE_DBTN126_n1952 n1952 INVX2TS
XFE_DBTC125_n564 FE_DBTN125_n564 n564 INVX2TS
Xfull_reg_reg 1000 n1963 clk N2624 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][0] requesterAddressbuffer[2][0] 1001 clk n1285
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][1] requesterAddressbuffer[2][1] 1002 clk n1284
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][2] requesterAddressbuffer[2][2] 1003 clk n1283
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][3] requesterAddressbuffer[2][3] 1004 clk n1282
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][0] destinationAddressbuffer[2][0] 1005 clk
+ n1149 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][1] destinationAddressbuffer[2][1] 1006 clk
+ n1148 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][2] destinationAddressbuffer[2][2] 1007 clk
+ n1147 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][3] destinationAddressbuffer[2][3] 1008 clk
+ n1146 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][0] dataoutbuffer[0][0] 1009 clk n1273 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][1] dataoutbuffer[0][1] 1010 clk n1272 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][2] dataoutbuffer[0][2] 1011 clk n1271 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][3] dataoutbuffer[0][3] 1012 clk n1270 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][4] dataoutbuffer[0][4] 1013 clk n1269 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][5] dataoutbuffer[0][5] 1014 clk n1268 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[7] writeOutbuffer[7] 1015 clk n1225 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][4] destinationAddressbuffer[7][4] 1016 clk
+ n1205 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][5] destinationAddressbuffer[7][5] 1017 clk
+ n1204 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][6] destinationAddressbuffer[7][6] 1018 clk
+ n1203 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][7] destinationAddressbuffer[7][7] 1019 clk
+ n1202 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][8] destinationAddressbuffer[7][8] 1020 clk
+ n1201 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][9] destinationAddressbuffer[7][9] 1021 clk
+ n1200 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][11] destinationAddressbuffer[7][11] 1022 clk
+ n1198 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[6] writeOutbuffer[6] 1023 clk n1224 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][4] destinationAddressbuffer[6][4] 1024 clk
+ n1193 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][5] destinationAddressbuffer[6][5] 1025 clk
+ n1192 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][6] destinationAddressbuffer[6][6] 1026 clk
+ n1191 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][7] destinationAddressbuffer[6][7] 1027 clk
+ n1190 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][8] destinationAddressbuffer[6][8] 1028 clk
+ n1189 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][9] destinationAddressbuffer[6][9] 1029 clk
+ n1188 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][10] destinationAddressbuffer[6][10] 1030 clk
+ n1187 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][11] destinationAddressbuffer[6][11] 1031 clk
+ n1186 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[3] writeOutbuffer[3] 1032 clk n1221 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][4] destinationAddressbuffer[3][4] 1033 clk
+ n1157 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][5] destinationAddressbuffer[3][5] 1034 clk
+ n1156 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][6] destinationAddressbuffer[3][6] 1035 clk
+ n1155 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][7] destinationAddressbuffer[3][7] 1036 clk
+ n1154 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][8] destinationAddressbuffer[3][8] 1037 clk
+ n1153 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][9] destinationAddressbuffer[3][9] 1038 clk
+ n1152 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][10] destinationAddressbuffer[3][10] 1039 clk
+ n1151 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][11] destinationAddressbuffer[3][11] 1040 clk
+ n1150 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[2] writeOutbuffer[2] 1041 clk n1220 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][4] destinationAddressbuffer[2][4] 1042 clk
+ n1145 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][5] destinationAddressbuffer[2][5] 1043 clk
+ n1144 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][6] destinationAddressbuffer[2][6] 1044 clk
+ n1143 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][7] destinationAddressbuffer[2][7] 1045 clk
+ n1142 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][8] destinationAddressbuffer[2][8] 1046 clk
+ n1141 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][9] destinationAddressbuffer[2][9] 1047 clk
+ n1140 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][10] destinationAddressbuffer[2][10] 1048 clk
+ n1139 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][11] destinationAddressbuffer[2][11] 1049 clk
+ n1138 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][0] dataoutbuffer[7][0] 1050 clk n1231 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][1] dataoutbuffer[7][1] 1051 clk n1230 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][2] dataoutbuffer[7][2] 1052 clk n1229 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][3] dataoutbuffer[7][3] 1053 clk n1228 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][4] dataoutbuffer[7][4] 1054 clk n1227 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][5] dataoutbuffer[7][5] 1055 clk n1226 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][0] dataoutbuffer[6][0] 1056 clk n1237 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][1] dataoutbuffer[6][1] 1057 clk n1236 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][2] dataoutbuffer[6][2] 1058 clk n1235 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][3] dataoutbuffer[6][3] 1059 clk n1234 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][4] dataoutbuffer[6][4] 1060 clk n1233 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][5] dataoutbuffer[6][5] 1061 clk n1232 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][0] requesterAddressbuffer[5][0] 1062 clk n1297
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][1] requesterAddressbuffer[5][1] 1063 clk n1296
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][2] requesterAddressbuffer[5][2] 1064 clk n1295
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][3] requesterAddressbuffer[5][3] 1065 clk n1294
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][0] destinationAddressbuffer[5][0] 1066 clk
+ n1185 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][1] destinationAddressbuffer[5][1] 1067 clk
+ n1184 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][2] destinationAddressbuffer[5][2] 1068 clk
+ n1183 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][3] destinationAddressbuffer[5][3] 1069 clk
+ n1182 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][0] requesterAddressbuffer[4][0] 1070 clk n1293
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][1] requesterAddressbuffer[4][1] 1071 clk n1292
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][2] requesterAddressbuffer[4][2] 1072 clk n1291
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][3] requesterAddressbuffer[4][3] 1073 clk n1290
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][0] destinationAddressbuffer[4][0] 1074 clk
+ n1173 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][1] destinationAddressbuffer[4][1] 1075 clk
+ n1172 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][2] destinationAddressbuffer[4][2] 1076 clk
+ n1171 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][3] destinationAddressbuffer[4][3] 1077 clk
+ n1170 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][0] dataoutbuffer[3][0] 1078 clk n1255 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][1] dataoutbuffer[3][1] 1079 clk n1254 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][2] dataoutbuffer[3][2] 1080 clk n1253 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][3] dataoutbuffer[3][3] 1081 clk n1252 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][4] dataoutbuffer[3][4] 1082 clk n1251 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][5] dataoutbuffer[3][5] 1083 clk n1250 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][0] dataoutbuffer[2][0] 1084 clk n1261 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][1] dataoutbuffer[2][1] 1085 clk n1260 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][2] dataoutbuffer[2][2] 1086 clk n1259 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][3] dataoutbuffer[2][3] 1087 clk n1258 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][4] dataoutbuffer[2][4] 1088 clk n1257 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][5] dataoutbuffer[2][5] 1089 clk n1256 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][0] requesterAddressbuffer[1][0] 1090 clk n1281
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][1] requesterAddressbuffer[1][1] 1091 clk n1280
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][2] requesterAddressbuffer[1][2] 1092 clk n1279
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][3] requesterAddressbuffer[1][3] 1093 clk n1278
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][0] destinationAddressbuffer[1][0] 1094 clk
+ n1137 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][1] destinationAddressbuffer[1][1] 1095 clk
+ n1136 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][2] destinationAddressbuffer[1][2] 1096 clk
+ n1135 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][3] destinationAddressbuffer[1][3] 1097 clk
+ n1134 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][0] requesterAddressbuffer[0][0] 1098 clk n1277
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][1] requesterAddressbuffer[0][1] 1099 clk n1276
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][2] requesterAddressbuffer[0][2] 1100 clk n1275
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][3] requesterAddressbuffer[0][3] 1101 clk n1274
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][0] destinationAddressbuffer[0][0] 1102 clk
+ n1125 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][1] destinationAddressbuffer[0][1] 1103 clk
+ n1124 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][2] destinationAddressbuffer[0][2] 1104 clk
+ n1123 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][3] destinationAddressbuffer[0][3] 1105 clk
+ n1122 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][0] requesterAddressbuffer[7][0] 1106 clk n1305
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][1] requesterAddressbuffer[7][1] 1107 clk n1304
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][2] requesterAddressbuffer[7][2] 1108 clk n1303
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][3] requesterAddressbuffer[7][3] 1109 clk n1302
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][0] destinationAddressbuffer[7][0] 1110 clk
+ n1209 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][1] destinationAddressbuffer[7][1] 1111 clk
+ n1208 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][2] destinationAddressbuffer[7][2] 1112 clk
+ n1207 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][3] destinationAddressbuffer[7][3] 1113 clk
+ n1206 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][0] requesterAddressbuffer[6][0] 1114 clk n1301
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][1] requesterAddressbuffer[6][1] 1115 clk n1300
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][2] requesterAddressbuffer[6][2] 1116 clk n1299
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][3] requesterAddressbuffer[6][3] 1117 clk n1298
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][0] destinationAddressbuffer[6][0] 1118 clk
+ n1197 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][1] destinationAddressbuffer[6][1] 1119 clk
+ n1196 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][2] destinationAddressbuffer[6][2] 1120 clk
+ n1195 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][3] destinationAddressbuffer[6][3] 1121 clk
+ n1194 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][0] dataoutbuffer[5][0] 1122 clk n1243 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][1] dataoutbuffer[5][1] 1123 clk n1242 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][2] dataoutbuffer[5][2] 1124 clk n1241 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][3] dataoutbuffer[5][3] 1125 clk n1240 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][4] dataoutbuffer[5][4] 1126 clk n1239 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][5] dataoutbuffer[5][5] 1127 clk n1238 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][0] dataoutbuffer[4][0] 1128 clk n1249 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][1] dataoutbuffer[4][1] 1129 clk n1248 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][2] dataoutbuffer[4][2] 1130 clk n1247 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][3] dataoutbuffer[4][3] 1131 clk n1246 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][4] dataoutbuffer[4][4] 1132 clk n1245 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][5] dataoutbuffer[4][5] 1133 clk n1244 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][0] requesterAddressbuffer[3][0] 1134 clk n1289
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][1] requesterAddressbuffer[3][1] 1135 clk n1288
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][2] requesterAddressbuffer[3][2] 1136 clk n1287
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][3] requesterAddressbuffer[3][3] 1137 clk n1286
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][0] destinationAddressbuffer[3][0] 1138 clk
+ n1161 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][1] destinationAddressbuffer[3][1] 1139 clk
+ n1160 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][2] destinationAddressbuffer[3][2] 1140 clk
+ n1159 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][3] destinationAddressbuffer[3][3] 1141 clk
+ n1158 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][0] dataoutbuffer[1][0] 1142 clk n1267 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][1] dataoutbuffer[1][1] 1143 clk n1266 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][2] dataoutbuffer[1][2] 1144 clk n1265 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][3] dataoutbuffer[1][3] 1145 clk n1264 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][4] dataoutbuffer[1][4] 1146 clk n1263 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][5] dataoutbuffer[1][5] 1147 clk n1262 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[5] writeOutbuffer[5] 1148 clk n1223 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][4] destinationAddressbuffer[5][4] 1149 clk
+ n1181 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][5] destinationAddressbuffer[5][5] 1150 clk
+ n1180 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][6] destinationAddressbuffer[5][6] 1151 clk
+ n1179 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][7] destinationAddressbuffer[5][7] 1152 clk
+ n1178 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][8] destinationAddressbuffer[5][8] 1153 clk
+ n1177 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][9] destinationAddressbuffer[5][9] 1154 clk
+ n1176 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][10] destinationAddressbuffer[5][10] 1155 clk
+ n1175 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][11] destinationAddressbuffer[5][11] 1156 clk
+ n1174 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[4] writeOutbuffer[4] 1157 clk n1222 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][4] destinationAddressbuffer[4][4] 1158 clk
+ n1169 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][5] destinationAddressbuffer[4][5] 1159 clk
+ n1168 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][6] destinationAddressbuffer[4][6] 1160 clk
+ n1167 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][7] destinationAddressbuffer[4][7] 1161 clk
+ n1166 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][8] destinationAddressbuffer[4][8] 1162 clk
+ n1165 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][9] destinationAddressbuffer[4][9] 1163 clk
+ n1164 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][10] destinationAddressbuffer[4][10] 1164 clk
+ n1163 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][11] destinationAddressbuffer[4][11] 1165 clk
+ n1162 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[1] writeOutbuffer[1] 1166 clk n1219 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][4] destinationAddressbuffer[1][4] 1167 clk
+ n1133 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][5] destinationAddressbuffer[1][5] 1168 clk
+ n1132 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][6] destinationAddressbuffer[1][6] 1169 clk
+ n1131 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][7] destinationAddressbuffer[1][7] 1170 clk
+ n1130 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][8] destinationAddressbuffer[1][8] 1171 clk
+ n1129 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][9] destinationAddressbuffer[1][9] 1172 clk
+ n1128 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][10] destinationAddressbuffer[1][10] 1173 clk
+ n1127 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][11] destinationAddressbuffer[1][11] 1174 clk
+ n1126 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[0] writeOutbuffer[0] 1175 clk n1218 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][4] destinationAddressbuffer[0][4] 1176 clk
+ n1121 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][5] destinationAddressbuffer[0][5] 1177 clk
+ n1120 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][6] destinationAddressbuffer[0][6] 1178 clk
+ n1119 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][7] destinationAddressbuffer[0][7] 1179 clk
+ n1118 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][8] destinationAddressbuffer[0][8] 1180 clk
+ n1117 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][9] destinationAddressbuffer[0][9] 1181 clk
+ n1116 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][10] destinationAddressbuffer[0][10] 1182 clk
+ n1115 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][11] destinationAddressbuffer[0][11] 1183 clk
+ n1114 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][10] destinationAddressbuffer[7][10] 1184 clk
+ n1199 VDD VDD DFFNSRX1TS
XwriteOut_reg writeOut 1185 clk n1328 VDD VDD DFFNSRX1TS
XdestinationAddressOut_reg[4] destinationAddressOut[4] 1186 clk n1319 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[5] destinationAddressOut[5] 1187 clk n1318 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[6] destinationAddressOut[6] 1188 clk n1317 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[7] destinationAddressOut[7] 1189 clk n1316 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[8] destinationAddressOut[8] 1190 clk n1315 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[9] destinationAddressOut[9] 1191 clk n1314 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[10] destinationAddressOut[10] 1192 clk n1313 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[11] destinationAddressOut[11] 1193 clk n1312 VDD VDD
+ DFFNSRX1TS
XreadOut_reg readOut 1194 clk n1329 VDD VDD DFFNSRX1TS
XrequesterAddressOut_reg[0] requesterAddressOut[0] 1195 clk n1327 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[1] requesterAddressOut[1] 1196 clk n1326 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[2] requesterAddressOut[2] 1197 clk n1325 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[3] requesterAddressOut[3] 1198 clk n1324 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[0] destinationAddressOut[0] 1199 clk n1323 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[1] destinationAddressOut[1] 1200 clk n1322 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[2] destinationAddressOut[2] 1201 clk n1321 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[3] destinationAddressOut[3] 1202 clk n1320 VDD VDD
+ DFFNSRX1TS
XdataOut_reg[0] dataOut[0] 1203 clk n1311 VDD VDD DFFNSRX1TS
XdataOut_reg[1] dataOut[1] 1204 clk n1310 VDD VDD DFFNSRX1TS
XdataOut_reg[2] dataOut[2] 1205 clk n1309 VDD VDD DFFNSRX1TS
XdataOut_reg[3] dataOut[3] 1206 clk n1308 VDD VDD DFFNSRX1TS
XdataOut_reg[4] dataOut[4] 1207 clk n1307 VDD VDD DFFNSRX1TS
XdataOut_reg[5] dataOut[5] 1208 clk n1306 VDD VDD DFFNSRX1TS
Xread_reg_reg[1] n1956 n1955 clk n1330 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[0] n1954 n1958 clk n1335 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[2] n1959 n1960 clk n1333 VDD VDD DFFNSRX1TS
Xread_reg_reg[0] n1949 n1961 clk n1336 VDD VDD DFFNSRX1TS
Xread_reg_reg[2] n1952 n1953 clk n1331 VDD VDD DFFNSRX1TS
Xempty_reg_reg n1951 n1950 clk n1332 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[7] readOutbuffer[7] n1964 clk n1217 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[4] readOutbuffer[4] n1967 clk n1214 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[6] readOutbuffer[6] n1965 clk n1216 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[5] readOutbuffer[5] n1966 clk n1215 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[0] readOutbuffer[0] n1971 clk n1210 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[2] readOutbuffer[2] n1969 clk n1212 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[1] readOutbuffer[1] n1970 clk n1211 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[3] readOutbuffer[3] n1968 clk n1213 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[1] n1957 n1962 clk n1334 VDD VDD DFFNSRX1TS
XU4 n386 n124 selectBit_WEST NAND2BX1TS
XU5 n20 FE_DBTN133_n1954 n508 NOR2XLTS
XU7 n511 selectBit_WEST selectBit_EAST readReady NOR3XLTS
XU8 n140 n122 n133 NOR2XLTS
XU9 n1632 n126 n388 NOR2XLTS
XU10 n1620 n1622 INVX2TS
XU11 n1609 n1611 INVX2TS
XU12 n1596 n1598 INVX2TS
XU13 n1585 n1587 INVX2TS
XU15 n1645 n1647 INVX2TS
XU16 n542 selectBit_NORTH selectBit_SOUTH NOR2XLTS
XU17 n135 n1633 n134 NOR2XLTS
XU18 n326 n1651 n325 NOR2XLTS
XU19 n131 FE_DBTN146_n186 n1636 NOR2XLTS
XU20 n230 n1608 n231 NOR2XLTS
XU21 n36 n1591 FE_DBTN146_n186 NOR2XLTS
XU22 n185 n1647 n1641 n189 NOR3XLTS
XU23 n130 n28 n133 NOR2XLTS
XU24 n92 n1594 n91 NOR2XLTS
XU25 n492 n494 FE_DBTN127_n1953 n491 OAI21XLTS
XU27 n333 n1654 n325 NOR2X1TS
XU28 n192 n1639 n191 NOR2X1TS
XU29 n133 n134 n129 NAND2BXLTS
XU30 n282 n281 n280 NAND2BXLTS
XU31 n402 n401 n400 NAND2BXLTS
XU32 n191 n189 n188 NAND2BXLTS
XU33 n231 n229 n228 NAND2BXLTS
XU34 n325 n324 n323 NAND2BXLTS
XU35 n91 n89 n88 NAND2BXLTS
XU36 n485 FE_DBTN140_n1960 n483 XNOR2X1TS
XU37 n1587 n126 n274 NOR2X1TS
XU38 n483 n498 n490 FE_DBTN150_n1962 n488 ADDFX1TS
XU39 n388 n125 selectBit_EAST NAND2BX1TS
XU40 n1605 n26 n223 FE_DBTN159_n8 NAND3X1TS
XU41 n1583 FE_DBTN150_n1962 n26 n223 NAND3X1TS
XU42 n1633 n1635 INVX1TS
XU43 n313 n223 FE_DBTN159_n8 NOR2X1TS
XU44 n30 n9 FE_DBTN159_n8 NOR2X1TS
XU45 n320 FE_DBTN146_n186 n1662 NOR2X1TS
XU46 n186 n527 n1963 AND2X2TS
XU48 n467 n480 selectBit_WEST readReady n463 ADDFX1TS
XU49 n19 n16 n468 FE_DBTN150_n1962 n18 ADDFX1TS
XU50 n508 selectBit_NORTH INVX2TS
XU51 n468 n463 selectBit_SOUTH selectBit_NORTH selectBit_EAST ADDFX1TS
XU52 n1611 n314 n313 n274 NOR3X1TS
XU53 n228 n1614 n1611 NOR2XLTS
XU54 n541 readReady selectBit_WEST selectBit_EAST NOR3BXLTS
XU55 n134 n132 n1636 NAND2X1TS
XU56 n1429 n279 FE_DBTN156_n12 OR2X1TS
XU58 n1460 n226 FE_DBTN157_n11 OR2X1TS
XU59 n1362 n187 FE_DBTN155_n13 OR2X1TS
XU60 n1397 n132 n131 OR2X1TS
XU61 n1496 n87 FE_DBTN158_n10 OR2X1TS
XU62 n1547 n37 n36 OR2X1TS
XU63 n500 n486 n485 XOR2X1TS
XU64 n1636 FE_DBTN150_n1962 n1954 readReady FE_DBTN130_n1959 NAND4XLTS
XU66 n1662 FE_DBTN137_n1958 readReady FE_DBTN130_n1959 FE_DBTN134_n1957
+ NAND4XLTS
XU67 n1661 n16 n79 n386 NOR3XLTS
XU68 n1651 n1654 INVX2TS
XU69 n1655 n1657 INVX2TS
XU70 n1647 n17 n182 n386 NOR3XLTS
XU71 n1641 n1644 INVX2TS
XU73 n1673 n16 n17 n386 NOR3X1TS
XU74 n1667 n1670 INVX2TS
XU75 n1614 n16 n79 n272 NOR3X1TS
XU77 n1601 n17 n182 n272 NOR3XLTS
XU79 n1626 n16 n17 n272 NOR3XLTS
XU81 n1591 FE_DBTN137_n1958 FE_DBTN150_n1962 FE_DBTN140_n1960 readReady
+ NAND4XLTS
XU83 n564 n542 n1951 n541 NAND3XLTS
XU84 n555 n527 FE_DBTN129_n678 CLKAND2X2TS
XU85 n487 n482 n480 CLKAND2X2TS
XU86 n280 n1626 n1622 NOR2XLTS
XU87 n38 n1590 n1587 NOR2XLTS
XU88 n457 n471 n534 FE_DBTN134_n1957 n465 ADDFX1TS
XU89 n400 n1673 n1670 NOR2XLTS
XU90 n23 FE_DBTN133_n1954 n508 n20 AO21X1TS
XU91 n125 n30 n25 n28 OAI21XLTS
XU92 n522 selectBit_NORTH n511 n510 NAND3XLTS
XU93 n521 selectBit_SOUTH n511 n508 NAND3XLTS
XU94 n129 n1635 n1632 NOR2XLTS
XU95 n323 n1661 n1657 NOR2XLTS
XU96 n224 n20 FE_DBTN140_n1960 FE_DBTN134_n1957 NAND3XLTS
XU97 n188 n1647 n1644 NOR2XLTS
XU98 n88 n1601 n1598 NOR2XLTS
XU99 n40 n39 n38 NAND2BXLTS
XU100 n477 n457 n459 XOR2XLTS
XU101 n461 FE_DBTN150_n1962 n1955 n459 OAI21XLTS
XU103 n124 FE_DBTN140_n1960 n19 XOR2X1TS
XU104 n488 n482 n481 CLKAND2X2TS
XU105 n502 n186 reset NOR2XLTS
XU106 n1635 n182 n79 n386 NOR3X1TS
XU107 n1630 n1632 INVX2TS
XU108 n1654 n26 n8 n9 NOR3XLTS
XU109 n1658 n1661 INVX2TS
XU110 n1657 n314 n313 n388 NOR3XLTS
XU111 n1648 FE_DBTN150_n1962 readReady FE_DBTN133_n1954 FE_DBTN130_n1959
+ NAND4XLTS
XU112 n1640 n26 n22 FE_DBTN159_n8 NOR3XLTS
XU113 n1639 n1640 INVX2TS
XU114 n1674 readReady FE_DBTN133_n1954 FE_DBTN134_n1957 FE_DBTN130_n1959
+ NAND4XLTS
XU115 n1666 n26 n8 n22 NOR3XLTS
XU116 n1671 n1673 INVX2TS
XU117 n1664 n1666 INVX2TS
XU118 n1670 n389 n388 n273 NOR3BXLTS
XU119 n1615 FE_DBTN137_n1958 FE_DBTN140_n1960 readReady FE_DBTN134_n1957
+ NAND4XLTS
XU120 n1612 n1614 INVX2TS
XU121 n1602 FE_DBTN150_n1962 FE_DBTN140_n1960 readReady FE_DBTN133_n1954
+ NAND4XLTS
XU122 n1594 n1595 INVX2TS
XU123 n1599 n1601 INVX2TS
XU124 n1627 FE_DBTN140_n1960 readReady FE_DBTN133_n1954 FE_DBTN134_n1957
+ NAND4XLTS
XU125 n1619 n8 n22 n25 NOR3XLTS
XU126 n1618 n1619 INVX2TS
XU127 n1623 n1626 INVX2TS
XU128 n1622 n389 n274 n273 NOR3BXLTS
XU129 n1588 n16 n17 n124 selectBit_WEST NAND4XLTS
XU130 n1584 n1583 INVX2TS
XU131 n148 destinationAddressIn_SOUTH[11] INVX2TS
XU132 n152 destinationAddressIn_SOUTH[10] INVX2TS
XU133 n138 destinationAddressIn_SOUTH[9] INVX2TS
XU134 n143 destinationAddressIn_SOUTH[8] INVX2TS
XU135 n1333 n1959 n502 n501 n500 AO22XLTS
XU136 n1335 n1954 n502 n501 n497 AO22XLTS
XU137 n1334 FE_DBTN150_n1962 n502 n501 n498 AO22XLTS
XU138 n1332 n186 n453 n496 OAI21XLTS
XU139 n1306 n877 n876 n875 n874 NAND4XLTS
XU140 n1307 n853 n852 n851 n850 NAND4XLTS
XU141 n1308 n841 n840 n839 n838 NAND4XLTS
XU142 n1309 n829 n828 n827 n826 NAND4XLTS
XU143 n1310 n810 n809 n808 n807 NAND4XLTS
XU144 n1311 n790 n789 n788 n787 NAND4XLTS
XU145 n1320 n660 n659 n658 n657 NAND4XLTS
XU146 n1321 n648 n647 n646 n645 NAND4XLTS
XU147 n1322 n629 n628 n627 n626 NAND4XLTS
XU148 n1323 n614 n613 n612 n611 NAND4XLTS
XU149 n1324 n603 n602 n601 n657 NAND4XLTS
XU150 n1325 n592 n591 n590 n645 NAND4XLTS
XU151 n1326 n584 n583 n582 n626 NAND4XLTS
XU152 n1327 n567 n566 n565 n611 NAND4XLTS
XU153 n1329 n545 n544 n543 n564 NAND4XLTS
XU154 n1312 n780 n779 n778 NAND3XLTS
XU155 n1313 n766 n765 n764 NAND3XLTS
XU156 n1314 n751 n750 n749 NAND3XLTS
XU157 n1315 n733 n732 n731 NAND3XLTS
XU158 n1316 n719 n718 n717 NAND3XLTS
XU159 n1317 n708 n707 n706 NAND3XLTS
XU160 n1318 n693 n692 n691 NAND3XLTS
XU161 n1319 n671 n670 n669 NAND3XLTS
XU162 n1328 n558 n557 n556 NAND3XLTS
XU163 n1262 n1351 n1350 n1349 NAND3XLTS
XU164 n1263 n1345 n1344 n1343 NAND3XLTS
XU165 n1264 n1339 n1338 n1337 NAND3XLTS
XU166 n1265 n1110 n1109 n1108 NAND3XLTS
XU167 n1266 n1103 n1102 n1101 NAND3XLTS
XU168 n1267 n1096 n1095 n1094 NAND3XLTS
XU169 n1158 n1824 n1823 n1822 NAND3XLTS
XU170 n1159 n1814 n1813 n1812 NAND3XLTS
XU171 n1160 n1807 n1806 n1805 NAND3XLTS
XU172 n1161 n1799 n1798 n1797 NAND3XLTS
XU173 n1286 n979 n978 n977 NAND3XLTS
XU174 n1287 n974 n973 n972 NAND3XLTS
XU175 n1288 n967 n966 n965 NAND3XLTS
XU176 n1289 n960 n959 n958 NAND3XLTS
XU177 n1244 n1450 n1449 n1448 NAND3XLTS
XU178 n1245 n1445 n1444 n1443 NAND3XLTS
XU179 n1246 n1439 n1438 n1437 NAND3XLTS
XU180 n1247 n1435 n1434 n1433 NAND3XLTS
XU181 n1248 n1428 n1427 n1426 NAND3XLTS
XU182 n1249 n1422 n1421 n1420 NAND3XLTS
XU183 n1238 n1479 n1478 n1477 NAND3XLTS
XU184 n1239 n1475 n1474 n1473 NAND3XLTS
XU185 n1240 n1470 n1469 n1468 NAND3XLTS
XU186 n1241 n1465 n1464 n1463 NAND3XLTS
XU187 n1242 n1459 n1458 n1457 NAND3XLTS
XU188 n1243 n1454 n1453 n1452 NAND3XLTS
XU189 n1194 n1733 n1732 n1731 NAND3XLTS
XU190 n1195 n1727 n1726 n1725 NAND3XLTS
XU191 n1196 n1717 n1716 n1715 NAND3XLTS
XU192 n1197 n1709 n1708 n1707 NAND3XLTS
XU193 n1298 n912 n911 n910 NAND3XLTS
XU194 n1299 n906 n905 n904 NAND3XLTS
XU195 n1300 n902 n901 n900 NAND3XLTS
XU196 n1301 n897 n896 n895 NAND3XLTS
XU197 n1206 n1704 n1703 n1702 NAND3XLTS
XU198 n1207 n1697 n1696 n1695 NAND3XLTS
XU199 n1208 n1688 n1687 n1686 NAND3XLTS
XU200 n1209 n1680 n1679 n1678 NAND3XLTS
XU201 n1302 n894 n893 n892 NAND3XLTS
XU202 n1303 n888 n887 n886 NAND3XLTS
XU203 n1304 n885 n884 n883 NAND3XLTS
XU204 n1305 n881 n880 n879 NAND3XLTS
XU205 n1122 n1933 n1932 n1931 NAND3XLTS
XU206 n1123 n1922 n1921 n1920 NAND3XLTS
XU207 n1124 n1910 n1909 n1908 NAND3XLTS
XU208 n1125 n1899 n1898 n1897 NAND3XLTS
XU209 n1274 n1056 n1055 n1054 NAND3XLTS
XU210 n1275 n1047 n1046 n1045 NAND3XLTS
XU211 n1276 n1041 n1040 n1039 NAND3XLTS
XU212 n1277 n1034 n1033 n1032 NAND3XLTS
XU213 n1134 n1891 n1890 n1889 NAND3XLTS
XU214 n1135 n1880 n1879 n1878 NAND3XLTS
XU215 n1136 n1868 n1867 n1866 NAND3XLTS
XU216 n1137 n1857 n1856 n1855 NAND3XLTS
XU217 n1278 n1027 n1026 n1025 NAND3XLTS
XU218 n1279 n1018 n1017 n1016 NAND3XLTS
XU219 n1280 n1010 n1009 n1008 NAND3XLTS
XU220 n1281 n1003 n1002 n1001 NAND3XLTS
XU221 n1256 n1386 n1385 n1384 NAND3XLTS
XU222 n1257 n1379 n1378 n1377 NAND3XLTS
XU223 n1258 n1372 n1371 n1370 NAND3XLTS
XU224 n1259 n1368 n1367 n1366 NAND3XLTS
XU225 n1260 n1361 n1360 n1359 NAND3XLTS
XU226 n1261 n1356 n1355 n1354 NAND3XLTS
XU227 n1250 n1417 n1416 n1415 NAND3XLTS
XU228 n1251 n1410 n1409 n1408 NAND3XLTS
XU229 n1252 n1405 n1404 n1403 NAND3XLTS
XU230 n1253 n1401 n1400 n1399 NAND3XLTS
XU231 n1254 n1396 n1395 n1394 NAND3XLTS
XU232 n1255 n1391 n1390 n1389 NAND3XLTS
XU233 n1170 n1794 n1793 n1792 NAND3XLTS
XU234 n1171 n1786 n1785 n1784 NAND3XLTS
XU235 n1172 n1775 n1774 n1773 NAND3XLTS
XU236 n1173 n1766 n1765 n1764 NAND3XLTS
XU237 n1290 n954 n953 n952 NAND3XLTS
XU238 n1291 n946 n945 n944 NAND3XLTS
XU239 n1292 n941 n940 n939 NAND3XLTS
XU240 n1293 n935 n934 n933 NAND3XLTS
XU241 n1182 n1761 n1760 n1759 NAND3XLTS
XU242 n1183 n1754 n1753 n1752 NAND3XLTS
XU243 n1184 n1746 n1745 n1744 NAND3XLTS
XU244 n1185 n1737 n1736 n1735 NAND3XLTS
XU245 n1294 n929 n928 n927 NAND3XLTS
XU246 n1295 n925 n924 n923 NAND3XLTS
XU247 n1296 n921 n920 n919 NAND3XLTS
XU248 n1297 n916 n915 n914 NAND3XLTS
XU249 n1232 n1529 n1528 n1527 NAND3XLTS
XU250 n1233 n1521 n1520 n1519 NAND3XLTS
XU251 n1234 n1514 n1513 n1512 NAND3XLTS
XU252 n1235 n1506 n1505 n1504 NAND3XLTS
XU253 n1236 n1495 n1494 n1493 NAND3XLTS
XU254 n1237 n1486 n1485 n1484 NAND3XLTS
XU255 n1226 n1581 n1580 n1579 NAND3XLTS
XU256 n1227 n1571 n1570 n1569 NAND3XLTS
XU257 n1228 n1563 n1562 n1561 NAND3XLTS
XU258 n1229 n1555 n1554 n1553 NAND3XLTS
XU259 n1230 n1546 n1545 n1544 NAND3XLTS
XU260 n1231 n1537 n1536 n1535 NAND3XLTS
XU261 n1268 n1089 n1088 n1087 NAND3XLTS
XU262 n1269 n1084 n1083 n1082 NAND3XLTS
XU263 n1270 n1077 n1076 n1075 NAND3XLTS
XU264 n1271 n1073 n1072 n1071 NAND3XLTS
XU265 n1272 n1067 n1066 n1065 NAND3XLTS
XU266 n1273 n1062 n1061 n1060 NAND3XLTS
XU267 n1146 n1850 n1849 n1848 NAND3XLTS
XU268 n1147 n1844 n1843 n1842 NAND3XLTS
XU269 n1148 n1835 n1834 n1833 NAND3XLTS
XU270 n1149 n1828 n1827 n1826 NAND3XLTS
XU271 n1282 n996 n995 n994 NAND3XLTS
XU272 n1283 n991 n990 n989 NAND3XLTS
XU273 n1284 n988 n987 n986 NAND3XLTS
XU274 n1285 n983 n982 n981 NAND3XLTS
XU275 n495 n494 FE_DBTN127_n1953 n493 n492 AOI211XLTS
XU276 n493 FE_DBTN128_n1961 n497 XOR2XLTS
XU277 n359 n321 n320 OR2X1TS
XU278 n28 n30 n25 NAND2X1TS
XU279 n1 n1618 n282 OR2X1TS
XU280 n2 n1664 n402 OR2X1TS
XU281 n3 n1583 n40 OR2X1TS
XU282 n4 n1640 n191 OR2X1TS
XU283 n5 n1666 n402 OR2X1TS
XU284 n6 n1619 n282 OR2X1TS
XU285 n7 n1595 n91 OR2X1TS
XU286 n8 n20 FE_DBTN150_n1962 n24 OA21XLTS
XU287 n9 n23 n510 OR2X1TS
XU288 n10 FE_DBTN146_n186 n1602 OR2X1TS
XU289 n428 n398 FE_DBTN154_n14 OR2X1TS
XU290 n318 n1661 n1655 n324 NOR3XLTS
XU291 n34 n1590 n1585 n39 NOR3XLTS
XU292 n85 n1601 n1596 n89 NOR3XLTS
XU293 n225 n1614 n1609 n229 NOR3XLTS
XU294 n278 n1626 n1620 n281 NOR3XLTS
XU295 n396 n1673 n1667 n401 NOR3XLTS
XU296 n11 FE_DBTN146_n186 n1615 OR2X1TS
XU297 n12 FE_DBTN146_n186 n1627 OR2X1TS
XU298 n13 FE_DBTN146_n186 n1648 OR2X1TS
XU299 n14 FE_DBTN146_n186 n1674 OR2X1TS
XU300 n695 n1950 n522 NOR2XLTS
XU301 n547 n1950 n521 NOR2XLTS
XU329 n18 n17 FE_DBTN137_n1958 n463 ADDHX1TS
XU330 n79 n17 INVX2TS
XU333 n458 selectBit_WEST INVX2TS
XU334 n1590 n1588 INVX2TS
XU338 n510 selectBit_SOUTH INVX2TS
XU339 n223 n9 INVX2TS
XU342 n24 n20 FE_DBTN150_n1962 NAND2X1TS
XU344 n22 selectBit_SOUTH n23 NAND2X1TS
XU345 n273 selectBit_SOUTH n23 n22 OAI21XLTS
XU346 n126 n313 n273 NAND2X1TS
XU347 n127 n24 INVX2TS
XU349 n25 FE_DBTN140_n1960 n24 n127 FE_DBTN130_n1959 AOI22X1TS
XU350 n26 n25 INVX2TS
XU352 n122 n28 INVX2TS
XU354 n274 selectBit_EAST n125 NAND2X1TS
XU355 n33 FE_DBTN140_n1960 n127 NAND2X1TS
XU361 n527 n542 n511 NAND2X1TS
XU365 n37 n38 n33 n1583 FE_DBTN146_n186 AOI31XLTS
XU368 n39 n37 n1591 NAND2X1TS
XU369 n890 n34 INVX2TS
XU378 n57 n1588 n39 OR2X1TS
XU382 n42 FE_DBTN152_n1547 destinationAddressbuffer[7][9] FE_DBTN153_n57
+ destinationAddressIn_WEST[9] AOI22X1TS
XU384 n62 n1584 n40 OR2X1TS
XU390 n41 FE_DBTN164_n3 destinationAddressIn_SOUTH[9] FE_DBTN151_n62
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU391 n1200 n890 FE_DBTN204_destinationAddressInBuffer_EAST_9_ n42 n41
+ OAI211XLTS
XU396 n46 FE_DBTN152_n1547 destinationAddressbuffer[7][10] FE_DBTN153_n57
+ destinationAddressIn_WEST[10] AOI22X1TS
XU404 n45 FE_DBTN164_n3 destinationAddressIn_SOUTH[10] FE_DBTN151_n62
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU405 n1199 n890 FE_DBTN207_destinationAddressInBuffer_EAST_10_ n46 n45
+ OAI211XLTS
XU413 n51 FE_DBTN152_n1547 destinationAddressbuffer[7][8] FE_DBTN153_n57
+ destinationAddressIn_WEST[8] AOI22X1TS
XU418 n50 FE_DBTN164_n3 destinationAddressIn_SOUTH[8] FE_DBTN151_n62
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU419 n1201 n890 FE_DBTN201_destinationAddressInBuffer_EAST_8_ n51 n50
+ OAI211XLTS
XU423 n55 FE_DBTN152_n1547 destinationAddressbuffer[7][11] FE_DBTN153_n57
+ destinationAddressIn_WEST[11] AOI22X1TS
XU428 n54 FE_DBTN164_n3 destinationAddressIn_SOUTH[11] FE_DBTN151_n62
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU429 n1198 n890 FE_DBTN210_destinationAddressInBuffer_EAST_11_ n55 n54
+ OAI211XLTS
XU433 n60 FE_DBTN152_n1547 writeOutbuffer[7] FE_DBTN153_n57 writeIn_WEST
+ AOI22X1TS
XU435 n156 writeIn_SOUTH INVX2TS
XU440 n59 FE_DBTN164_n3 writeIn_SOUTH FE_DBTN151_n62 writeIn_NORTH AOI22X1TS
XU441 n1225 n890 FE_DBTN213_writeInBuffer_EAST n60 n59 OAI211XLTS
XU446 n65 FE_DBTN152_n1547 destinationAddressbuffer[7][4] FE_DBTN153_n57
+ destinationAddressIn_WEST[4] AOI22X1TS
XU447 n174 destinationAddressIn_SOUTH[4] INVX2TS
XU450 n64 FE_DBTN164_n3 destinationAddressIn_SOUTH[4] FE_DBTN151_n62
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU451 n1205 n890 FE_DBTN191_destinationAddressInBuffer_EAST_4_ n65 n64
+ OAI211XLTS
XU455 n68 FE_DBTN152_n1547 destinationAddressbuffer[7][6] FE_DBTN153_n57
+ destinationAddressIn_WEST[6] AOI22X1TS
XU456 n180 destinationAddressIn_SOUTH[6] INVX2TS
XU458 n67 FE_DBTN164_n3 destinationAddressIn_SOUTH[6] FE_DBTN151_n62
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU459 n1203 n890 FE_DBTN197_destinationAddressInBuffer_EAST_6_ n68 n67
+ OAI211XLTS
XU463 n72 FE_DBTN152_n1547 destinationAddressbuffer[7][5] FE_DBTN153_n57
+ destinationAddressIn_WEST[5] AOI22X1TS
XU464 n167 destinationAddressIn_SOUTH[5] INVX2TS
XU466 n71 FE_DBTN164_n3 destinationAddressIn_SOUTH[5] FE_DBTN151_n62
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU467 n1204 n890 FE_DBTN194_destinationAddressInBuffer_EAST_5_ n72 n71
+ OAI211XLTS
XU471 n77 FE_DBTN152_n1547 destinationAddressbuffer[7][7] FE_DBTN153_n57
+ destinationAddressIn_WEST[7] AOI22X1TS
XU472 n162 destinationAddressIn_SOUTH[7] INVX2TS
XU474 n76 FE_DBTN164_n3 destinationAddressIn_SOUTH[7] FE_DBTN151_n62
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU475 n1202 n890 FE_DBTN200_destinationAddressInBuffer_EAST_7_ n77 n76
+ OAI211XLTS
XU476 n182 n16 INVX2TS
XU477 n272 n124 selectBit_WEST NAND2X1TS
XU478 n389 n223 FE_DBTN159_n8 n313 AOI21X1TS
XU479 n1598 n389 n274 n273 NOR3XLTS
XU481 n392 FE_DBTN137_n1958 n508 NOR2XLTS
XU483 n1595 n25 n22 FE_DBTN159_n8 NOR3XLTS
XU484 n83 FE_DBTN140_n1960 FE_DBTN150_n1962 n392 n1595 AOI31XLTS
XU485 n87 n88 n83 FE_DBTN146_n186 AOI21X1TS
XU487 n89 n87 n1602 NAND2X1TS
XU488 n1489 n85 INVX2TS
XU495 n106 n1599 n89 OR2X1TS
XU497 n94 FE_DBTN148_n1496 destinationAddressbuffer[6][11] FE_DBTN149_n106
+ destinationAddressIn_WEST[11] AOI22X1TS
XU503 n93 FE_DBTN160_n7 destinationAddressIn_NORTH[11] n92
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU504 n1186 n1489 FE_DBTN210_destinationAddressInBuffer_EAST_11_ n94 n93
+ OAI211XLTS
XU508 n97 FE_DBTN148_n1496 destinationAddressbuffer[6][8] FE_DBTN149_n106
+ destinationAddressIn_WEST[8] AOI22X1TS
XU514 n96 FE_DBTN160_n7 destinationAddressIn_NORTH[8] n92
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU515 n1189 n1489 FE_DBTN201_destinationAddressInBuffer_EAST_8_ n97 n96
+ OAI211XLTS
XU518 n100 FE_DBTN148_n1496 destinationAddressbuffer[6][10] FE_DBTN149_n106
+ destinationAddressIn_WEST[10] AOI22X1TS
XU521 n99 FE_DBTN160_n7 destinationAddressIn_NORTH[10] n92
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU522 n1187 n1489 FE_DBTN207_destinationAddressInBuffer_EAST_10_ n100 n99
+ OAI211XLTS
XU523 n105 FE_DBTN148_n1496 destinationAddressbuffer[6][9] FE_DBTN149_n106
+ destinationAddressIn_WEST[9] AOI22X1TS
XU529 n104 FE_DBTN160_n7 destinationAddressIn_NORTH[9] n92
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU530 n1188 n1489 FE_DBTN204_destinationAddressInBuffer_EAST_9_ n105 n104
+ OAI211XLTS
XU533 n108 FE_DBTN148_n1496 writeOutbuffer[6] FE_DBTN149_n106 writeIn_WEST
+ AOI22X1TS
XU537 n107 FE_DBTN160_n7 writeIn_NORTH n92 writeIn_SOUTH AOI22X1TS
XU538 n1224 n1489 FE_DBTN213_writeInBuffer_EAST n108 n107 OAI211XLTS
XU540 n110 FE_DBTN148_n1496 destinationAddressbuffer[6][5] FE_DBTN149_n106
+ destinationAddressIn_WEST[5] AOI22X1TS
XU546 n109 FE_DBTN160_n7 destinationAddressIn_NORTH[5] n92
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU547 n1192 n1489 FE_DBTN194_destinationAddressInBuffer_EAST_5_ n110 n109
+ OAI211XLTS
XU548 n113 FE_DBTN148_n1496 destinationAddressbuffer[6][7] FE_DBTN149_n106
+ destinationAddressIn_WEST[7] AOI22X1TS
XU552 n112 FE_DBTN160_n7 destinationAddressIn_NORTH[7] n92
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU553 n1190 n1489 FE_DBTN200_destinationAddressInBuffer_EAST_7_ n113 n112
+ OAI211XLTS
XU554 n116 FE_DBTN148_n1496 destinationAddressbuffer[6][4] FE_DBTN149_n106
+ destinationAddressIn_WEST[4] AOI22X1TS
XU558 n115 FE_DBTN160_n7 destinationAddressIn_NORTH[4] n92
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU559 n1193 n1489 FE_DBTN191_destinationAddressInBuffer_EAST_4_ n116 n115
+ OAI211XLTS
XU560 n120 FE_DBTN148_n1496 destinationAddressbuffer[6][6] FE_DBTN149_n106
+ destinationAddressIn_WEST[6] AOI22X1TS
XU564 n119 FE_DBTN160_n7 destinationAddressIn_NORTH[6] n92
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU565 n1191 n1489 FE_DBTN197_destinationAddressInBuffer_EAST_6_ n120 n119
+ OAI211XLTS
XU566 n516 selectBit_EAST INVX2TS
XU569 n128 n127 FE_DBTN130_n1959 NAND2X1TS
XU570 n132 n129 n28 n128 FE_DBTN146_n186 AOI31XLTS
XU572 n970 n130 INVX2TS
XU579 n139 n1635 n1630 n134 NOR3XLTS
XU582 n137 FE_DBTN147_n1397 destinationAddressbuffer[3][9] n139
+ destinationAddressIn_EAST[9] AOI22X1TS
XU588 n136 n140 destinationAddressIn_NORTH[9] n135 destinationAddressIn_WEST[9]
+ AOI22X1TS
XU589 n1152 n970 n138 n137 n136 OAI211XLTS
XU592 n142 FE_DBTN147_n1397 destinationAddressbuffer[3][8] n139
+ destinationAddressIn_EAST[8] AOI22X1TS
XU596 n141 n140 destinationAddressIn_NORTH[8] n135 destinationAddressIn_WEST[8]
+ AOI22X1TS
XU597 n1153 n970 n143 n142 n141 OAI211XLTS
XU600 n147 FE_DBTN147_n1397 destinationAddressbuffer[3][11] n139
+ destinationAddressIn_EAST[11] AOI22X1TS
XU606 n146 n140 destinationAddressIn_NORTH[11] n135
+ destinationAddressIn_WEST[11] AOI22X1TS
XU607 n1150 n970 n148 n147 n146 OAI211XLTS
XU608 n151 FE_DBTN147_n1397 destinationAddressbuffer[3][10] n139
+ destinationAddressIn_EAST[10] AOI22X1TS
XU612 n150 n140 destinationAddressIn_NORTH[10] n135
+ destinationAddressIn_WEST[10] AOI22X1TS
XU613 n1151 n970 n152 n151 n150 OAI211XLTS
XU616 n155 FE_DBTN147_n1397 writeOutbuffer[3] n139 writeIn_EAST AOI22X1TS
XU620 n154 n140 writeIn_NORTH n135 writeIn_WEST AOI22X1TS
XU621 n1221 n970 n156 n155 n154 OAI211XLTS
XU623 n161 FE_DBTN147_n1397 destinationAddressbuffer[3][7] n139
+ destinationAddressIn_EAST[7] AOI22X1TS
XU626 n160 n140 destinationAddressIn_NORTH[7] n135 destinationAddressIn_WEST[7]
+ AOI22X1TS
XU627 n1154 n970 n162 n161 n160 OAI211XLTS
XU628 n166 FE_DBTN147_n1397 destinationAddressbuffer[3][5] n139
+ destinationAddressIn_EAST[5] AOI22X1TS
XU630 n165 n140 destinationAddressIn_NORTH[5] n135 destinationAddressIn_WEST[5]
+ AOI22X1TS
XU631 n1156 n970 n167 n166 n165 OAI211XLTS
XU633 n173 FE_DBTN147_n1397 destinationAddressbuffer[3][4] n139
+ destinationAddressIn_EAST[4] AOI22X1TS
XU635 n172 n140 destinationAddressIn_NORTH[4] n135 destinationAddressIn_WEST[4]
+ AOI22X1TS
XU636 n1157 n970 n174 n173 n172 OAI211XLTS
XU637 n179 FE_DBTN147_n1397 destinationAddressbuffer[3][6] n139
+ destinationAddressIn_EAST[6] AOI22X1TS
XU639 n178 n140 destinationAddressIn_NORTH[6] n135 destinationAddressIn_WEST[6]
+ AOI22X1TS
XU640 n1155 n970 n180 n179 n178 OAI211XLTS
XU641 n314 n273 INVX2TS
XU643 n1644 n389 n273 n388 NOR3XLTS
XU644 n183 FE_DBTN150_n1962 n392 FE_DBTN130_n1959 n1640 AOI31XLTS
XU645 n187 n188 n183 FE_DBTN146_n186 AOI21X1TS
XU647 n189 n187 n1648 NAND2X1TS
XU648 n1352 n185 INVX2TS
XU655 n202 n1645 n189 OR2X1TS
XU657 n194 FE_DBTN144_n1362 destinationAddressbuffer[2][11] FE_DBTN145_n202
+ destinationAddressIn_WEST[11] AOI22X1TS
XU661 n193 FE_DBTN163_n4 destinationAddressIn_NORTH[11] n192
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU662 n1138 n1352 FE_DBTN210_destinationAddressInBuffer_EAST_11_ n194 n193
+ OAI211XLTS
XU664 n197 FE_DBTN144_n1362 destinationAddressbuffer[2][10] FE_DBTN145_n202
+ destinationAddressIn_WEST[10] AOI22X1TS
XU665 n196 FE_DBTN163_n4 destinationAddressIn_NORTH[10] n192
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU666 n1139 n1352 FE_DBTN207_destinationAddressInBuffer_EAST_10_ n197 n196
+ OAI211XLTS
XU671 n201 FE_DBTN144_n1362 destinationAddressbuffer[2][8] FE_DBTN145_n202
+ destinationAddressIn_WEST[8] AOI22X1TS
XU674 n200 FE_DBTN163_n4 destinationAddressIn_NORTH[8] n192
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU675 n1141 n1352 FE_DBTN201_destinationAddressInBuffer_EAST_8_ n201 n200
+ OAI211XLTS
XU677 n207 FE_DBTN144_n1362 destinationAddressbuffer[2][9] FE_DBTN145_n202
+ destinationAddressIn_WEST[9] AOI22X1TS
XU680 n206 FE_DBTN163_n4 destinationAddressIn_NORTH[9] n192
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU681 n1140 n1352 FE_DBTN204_destinationAddressInBuffer_EAST_9_ n207 n206
+ OAI211XLTS
XU683 n209 FE_DBTN144_n1362 writeOutbuffer[2] FE_DBTN145_n202 writeIn_WEST
+ AOI22X1TS
XU685 n208 FE_DBTN163_n4 writeIn_NORTH n192 writeIn_SOUTH AOI22X1TS
XU686 n1220 n1352 FE_DBTN213_writeInBuffer_EAST n209 n208 OAI211XLTS
XU688 n212 FE_DBTN144_n1362 destinationAddressbuffer[2][6] FE_DBTN145_n202
+ destinationAddressIn_WEST[6] AOI22X1TS
XU689 n211 FE_DBTN163_n4 destinationAddressIn_NORTH[6] n192
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU690 n1143 n1352 FE_DBTN197_destinationAddressInBuffer_EAST_6_ n212 n211
+ OAI211XLTS
XU691 n214 FE_DBTN144_n1362 destinationAddressbuffer[2][7] FE_DBTN145_n202
+ destinationAddressIn_WEST[7] AOI22X1TS
XU693 n213 FE_DBTN163_n4 destinationAddressIn_NORTH[7] n192
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU694 n1142 n1352 FE_DBTN200_destinationAddressInBuffer_EAST_7_ n214 n213
+ OAI211XLTS
XU695 n217 FE_DBTN144_n1362 destinationAddressbuffer[2][5] FE_DBTN145_n202
+ destinationAddressIn_WEST[5] AOI22X1TS
XU697 n216 FE_DBTN163_n4 destinationAddressIn_NORTH[5] n192
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU698 n1144 n1352 FE_DBTN194_destinationAddressInBuffer_EAST_5_ n217 n216
+ OAI211XLTS
XU699 n221 FE_DBTN144_n1362 destinationAddressbuffer[2][4] FE_DBTN145_n202
+ destinationAddressIn_WEST[4] AOI22X1TS
XU700 n220 FE_DBTN163_n4 destinationAddressIn_NORTH[4] n192
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU701 n1145 n1352 FE_DBTN191_destinationAddressInBuffer_EAST_4_ n221 n220
+ OAI211XLTS
XU703 n226 n228 n1605 n224 FE_DBTN146_n186 AOI31XLTS
XU705 n229 n226 n1615 NAND2X1TS
XU706 n1456 n225 INVX2TS
XU712 n243 n1612 n229 OR2X1TS
XU714 n234 FE_DBTN141_n1460 destinationAddressbuffer[5][8] FE_DBTN143_n243
+ destinationAddressIn_WEST[8] AOI22X1TS
XU715 n1608 n1605 INVX2TS
XU717 n250 n1605 n231 OR2X1TS
XU721 n233 n230 destinationAddressIn_NORTH[8] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU722 n1177 n1456 FE_DBTN201_destinationAddressInBuffer_EAST_8_ n234 n233
+ OAI211XLTS
XU726 n237 FE_DBTN141_n1460 destinationAddressbuffer[5][9] FE_DBTN143_n243
+ destinationAddressIn_WEST[9] AOI22X1TS
XU728 n236 n230 destinationAddressIn_NORTH[9] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU729 n1176 n1456 FE_DBTN204_destinationAddressInBuffer_EAST_9_ n237 n236
+ OAI211XLTS
XU732 n241 FE_DBTN141_n1460 destinationAddressbuffer[5][10] FE_DBTN143_n243
+ destinationAddressIn_WEST[10] AOI22X1TS
XU737 n240 n230 destinationAddressIn_NORTH[10] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU738 n1175 n1456 FE_DBTN207_destinationAddressInBuffer_EAST_10_ n241 n240
+ OAI211XLTS
XU740 n247 FE_DBTN141_n1460 destinationAddressbuffer[5][11] FE_DBTN143_n243
+ destinationAddressIn_WEST[11] AOI22X1TS
XU742 n246 n230 destinationAddressIn_NORTH[11] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU743 n1174 n1456 FE_DBTN210_destinationAddressInBuffer_EAST_11_ n247 n246
+ OAI211XLTS
XU746 n252 FE_DBTN141_n1460 writeOutbuffer[5] FE_DBTN143_n243 writeIn_WEST
+ AOI22X1TS
XU748 n251 n230 writeIn_NORTH FE_DBTN142_n250 writeIn_SOUTH AOI22X1TS
XU749 n1223 n1456 FE_DBTN213_writeInBuffer_EAST n252 n251 OAI211XLTS
XU751 n256 FE_DBTN141_n1460 destinationAddressbuffer[5][5] FE_DBTN143_n243
+ destinationAddressIn_WEST[5] AOI22X1TS
XU753 n255 n230 destinationAddressIn_NORTH[5] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU754 n1180 n1456 FE_DBTN194_destinationAddressInBuffer_EAST_5_ n256 n255
+ OAI211XLTS
XU755 n259 FE_DBTN141_n1460 destinationAddressbuffer[5][4] FE_DBTN143_n243
+ destinationAddressIn_WEST[4] AOI22X1TS
XU756 n258 n230 destinationAddressIn_NORTH[4] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU757 n1181 n1456 FE_DBTN191_destinationAddressInBuffer_EAST_4_ n259 n258
+ OAI211XLTS
XU758 n264 FE_DBTN141_n1460 destinationAddressbuffer[5][6] FE_DBTN143_n243
+ destinationAddressIn_WEST[6] AOI22X1TS
XU759 n263 n230 destinationAddressIn_NORTH[6] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU760 n1179 n1456 FE_DBTN197_destinationAddressInBuffer_EAST_6_ n264 n263
+ OAI211XLTS
XU761 n269 FE_DBTN141_n1460 destinationAddressbuffer[5][7] FE_DBTN143_n243
+ destinationAddressIn_WEST[7] AOI22X1TS
XU763 n268 n230 destinationAddressIn_NORTH[7] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU764 n1178 n1456 FE_DBTN200_destinationAddressInBuffer_EAST_7_ n269 n268
+ OAI211XLTS
XU765 n276 FE_DBTN140_n1960 n392 FE_DBTN134_n1957 n1619 AOI31XLTS
XU766 n279 n280 n276 FE_DBTN146_n186 AOI21X1TS
XU767 n281 n279 n1627 NAND2X1TS
XU768 n1425 n278 INVX2TS
XU774 n293 n1623 n281 OR2X1TS
XU776 n284 FE_DBTN138_n1429 destinationAddressbuffer[4][9] FE_DBTN139_n293
+ destinationAddressIn_WEST[9] AOI22X1TS
XU779 n283 FE_DBTN166_n1 destinationAddressIn_SOUTH[9] FE_DBTN161_n6
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU780 n1164 n1425 FE_DBTN204_destinationAddressInBuffer_EAST_9_ n284 n283
+ OAI211XLTS
XU783 n287 FE_DBTN138_n1429 destinationAddressbuffer[4][10] FE_DBTN139_n293
+ destinationAddressIn_WEST[10] AOI22X1TS
XU787 n286 FE_DBTN166_n1 destinationAddressIn_SOUTH[10] FE_DBTN161_n6
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU788 n1163 n1425 FE_DBTN207_destinationAddressInBuffer_EAST_10_ n287 n286
+ OAI211XLTS
XU792 n292 FE_DBTN138_n1429 destinationAddressbuffer[4][8] FE_DBTN139_n293
+ destinationAddressIn_WEST[8] AOI22X1TS
XU797 n291 FE_DBTN166_n1 destinationAddressIn_SOUTH[8] FE_DBTN161_n6
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU798 n1165 n1425 FE_DBTN201_destinationAddressInBuffer_EAST_8_ n292 n291
+ OAI211XLTS
XU800 n297 FE_DBTN138_n1429 destinationAddressbuffer[4][11] FE_DBTN139_n293
+ destinationAddressIn_WEST[11] AOI22X1TS
XU803 n296 FE_DBTN166_n1 destinationAddressIn_SOUTH[11] FE_DBTN161_n6
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU804 n1162 n1425 FE_DBTN210_destinationAddressInBuffer_EAST_11_ n297 n296
+ OAI211XLTS
XU806 n299 FE_DBTN138_n1429 writeOutbuffer[4] FE_DBTN139_n293 writeIn_WEST
+ AOI22X1TS
XU809 n298 FE_DBTN166_n1 writeIn_SOUTH FE_DBTN161_n6 writeIn_NORTH AOI22X1TS
XU810 n1222 n1425 FE_DBTN213_writeInBuffer_EAST n299 n298 OAI211XLTS
XU812 n302 FE_DBTN138_n1429 destinationAddressbuffer[4][6] FE_DBTN139_n293
+ destinationAddressIn_WEST[6] AOI22X1TS
XU814 n301 FE_DBTN166_n1 destinationAddressIn_SOUTH[6] FE_DBTN161_n6
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU815 n1167 n1425 FE_DBTN197_destinationAddressInBuffer_EAST_6_ n302 n301
+ OAI211XLTS
XU816 n304 FE_DBTN138_n1429 destinationAddressbuffer[4][5] FE_DBTN139_n293
+ destinationAddressIn_WEST[5] AOI22X1TS
XU817 n303 FE_DBTN166_n1 destinationAddressIn_SOUTH[5] FE_DBTN161_n6
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU818 n1168 n1425 FE_DBTN194_destinationAddressInBuffer_EAST_5_ n304 n303
+ OAI211XLTS
XU819 n308 FE_DBTN138_n1429 destinationAddressbuffer[4][4] FE_DBTN139_n293
+ destinationAddressIn_WEST[4] AOI22X1TS
XU820 n307 FE_DBTN166_n1 destinationAddressIn_SOUTH[4] FE_DBTN161_n6
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU821 n1169 n1425 FE_DBTN191_destinationAddressInBuffer_EAST_4_ n308 n307
+ OAI211XLTS
XU822 n312 FE_DBTN138_n1429 destinationAddressbuffer[4][7] FE_DBTN139_n293
+ destinationAddressIn_WEST[7] AOI22X1TS
XU823 n311 FE_DBTN166_n1 destinationAddressIn_SOUTH[7] FE_DBTN161_n6
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU824 n1166 n1425 FE_DBTN200_destinationAddressInBuffer_EAST_7_ n312 n311
+ OAI211XLTS
XU825 n316 n20 FE_DBTN134_n1957 FE_DBTN130_n1959 n1654 AOI31XLTS
XU826 n321 n323 n316 FE_DBTN146_n186 AOI21X1TS
XU827 n324 n321 n1662 NAND2X1TS
XU828 n1092 n318 INVX2TS
XU836 n346 n1658 n324 OR2X1TS
XU838 n330 FE_DBTN135_n359 destinationAddressbuffer[1][9] FE_DBTN136_n346
+ destinationAddressIn_WEST[9] AOI22X1TS
XU843 n329 n333 destinationAddressIn_NORTH[9] n326
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU844 n1128 n1092 FE_DBTN204_destinationAddressInBuffer_EAST_9_ n330 n329
+ OAI211XLTS
XU848 n338 FE_DBTN135_n359 destinationAddressbuffer[1][8] FE_DBTN136_n346
+ destinationAddressIn_WEST[8] AOI22X1TS
XU854 n337 n333 destinationAddressIn_NORTH[8] n326
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU855 n1129 n1092 FE_DBTN201_destinationAddressInBuffer_EAST_8_ n338 n337
+ OAI211XLTS
XU858 n345 FE_DBTN135_n359 destinationAddressbuffer[1][11] FE_DBTN136_n346
+ destinationAddressIn_WEST[11] AOI22X1TS
XU861 n344 n333 destinationAddressIn_NORTH[11] n326
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU862 n1126 n1092 FE_DBTN210_destinationAddressInBuffer_EAST_11_ n345 n344
+ OAI211XLTS
XU864 n353 FE_DBTN135_n359 destinationAddressbuffer[1][10] FE_DBTN136_n346
+ destinationAddressIn_WEST[10] AOI22X1TS
XU866 n352 n333 destinationAddressIn_NORTH[10] n326
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU867 n1127 n1092 FE_DBTN207_destinationAddressInBuffer_EAST_10_ n353 n352
+ OAI211XLTS
XU869 n358 FE_DBTN135_n359 writeOutbuffer[1] FE_DBTN136_n346 writeIn_WEST
+ AOI22X1TS
XU871 n357 n333 writeIn_NORTH n326 writeIn_SOUTH AOI22X1TS
XU872 n1219 n1092 FE_DBTN213_writeInBuffer_EAST n358 n357 OAI211XLTS
XU874 n365 FE_DBTN135_n359 destinationAddressbuffer[1][4] FE_DBTN136_n346
+ destinationAddressIn_WEST[4] AOI22X1TS
XU875 n364 n333 destinationAddressIn_NORTH[4] n326
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU876 n1133 n1092 FE_DBTN191_destinationAddressInBuffer_EAST_4_ n365 n364
+ OAI211XLTS
XU877 n371 FE_DBTN135_n359 destinationAddressbuffer[1][7] FE_DBTN136_n346
+ destinationAddressIn_WEST[7] AOI22X1TS
XU879 n370 n333 destinationAddressIn_NORTH[7] n326
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU880 n1130 n1092 FE_DBTN200_destinationAddressInBuffer_EAST_7_ n371 n370
+ OAI211XLTS
XU881 n378 FE_DBTN135_n359 destinationAddressbuffer[1][6] FE_DBTN136_n346
+ destinationAddressIn_WEST[6] AOI22X1TS
XU882 n377 n333 destinationAddressIn_NORTH[6] n326
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU883 n1131 n1092 FE_DBTN197_destinationAddressInBuffer_EAST_6_ n378 n377
+ OAI211XLTS
XU884 n384 FE_DBTN135_n359 destinationAddressbuffer[1][5] FE_DBTN136_n346
+ destinationAddressIn_WEST[5] AOI22X1TS
XU885 n383 n333 destinationAddressIn_NORTH[5] n326
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU886 n1132 n1092 FE_DBTN194_destinationAddressInBuffer_EAST_5_ n384 n383
+ OAI211XLTS
XU887 n393 n392 FE_DBTN134_n1957 FE_DBTN130_n1959 n1666 AOI31XLTS
XU888 n398 n400 n393 FE_DBTN146_n186 AOI21X1TS
XU889 n401 n398 n1674 NAND2X1TS
XU890 n1057 n396 INVX2TS
XU895 n418 n1671 n401 OR2X1TS
XU897 n406 FE_DBTN131_n428 destinationAddressbuffer[0][10] FE_DBTN132_n418
+ destinationAddressIn_WEST[10] AOI22X1TS
XU901 n405 FE_DBTN165_n2 destinationAddressIn_SOUTH[10] FE_DBTN162_n5
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU902 n1115 n1057 FE_DBTN207_destinationAddressInBuffer_EAST_10_ n406 n405
+ OAI211XLTS
XU905 n410 FE_DBTN131_n428 destinationAddressbuffer[0][9] FE_DBTN132_n418
+ destinationAddressIn_WEST[9] AOI22X1TS
XU908 n409 FE_DBTN165_n2 destinationAddressIn_SOUTH[9] FE_DBTN162_n5
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU909 n1116 n1057 FE_DBTN204_destinationAddressInBuffer_EAST_9_ n410 n409
+ OAI211XLTS
XU914 n417 FE_DBTN131_n428 destinationAddressbuffer[0][11] FE_DBTN132_n418
+ destinationAddressIn_WEST[11] AOI22X1TS
XU916 n416 FE_DBTN165_n2 destinationAddressIn_SOUTH[11] FE_DBTN162_n5
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU917 n1114 n1057 FE_DBTN210_destinationAddressInBuffer_EAST_11_ n417 n416
+ OAI211XLTS
XU919 n424 FE_DBTN131_n428 destinationAddressbuffer[0][8] FE_DBTN132_n418
+ destinationAddressIn_WEST[8] AOI22X1TS
XU924 n423 FE_DBTN165_n2 destinationAddressIn_SOUTH[8] FE_DBTN162_n5
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU925 n1117 n1057 FE_DBTN201_destinationAddressInBuffer_EAST_8_ n424 n423
+ OAI211XLTS
XU927 n427 FE_DBTN131_n428 writeOutbuffer[0] FE_DBTN132_n418 writeIn_WEST
+ AOI22X1TS
XU930 n426 FE_DBTN165_n2 writeIn_SOUTH FE_DBTN162_n5 writeIn_NORTH AOI22X1TS
XU931 n1218 n1057 FE_DBTN213_writeInBuffer_EAST n427 n426 OAI211XLTS
XU934 n432 FE_DBTN131_n428 destinationAddressbuffer[0][4] FE_DBTN132_n418
+ destinationAddressIn_WEST[4] AOI22X1TS
XU935 n431 FE_DBTN165_n2 destinationAddressIn_SOUTH[4] FE_DBTN162_n5
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU936 n1121 n1057 FE_DBTN191_destinationAddressInBuffer_EAST_4_ n432 n431
+ OAI211XLTS
XU937 n435 FE_DBTN131_n428 destinationAddressbuffer[0][7] FE_DBTN132_n418
+ destinationAddressIn_WEST[7] AOI22X1TS
XU938 n434 FE_DBTN165_n2 destinationAddressIn_SOUTH[7] FE_DBTN162_n5
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU939 n1118 n1057 FE_DBTN200_destinationAddressInBuffer_EAST_7_ n435 n434
+ OAI211XLTS
XU940 n438 FE_DBTN131_n428 destinationAddressbuffer[0][5] FE_DBTN132_n418
+ destinationAddressIn_WEST[5] AOI22X1TS
XU941 n437 FE_DBTN165_n2 destinationAddressIn_SOUTH[5] FE_DBTN162_n5
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU942 n1120 n1057 FE_DBTN194_destinationAddressInBuffer_EAST_5_ n438 n437
+ OAI211XLTS
XU943 n444 FE_DBTN131_n428 destinationAddressbuffer[0][6] FE_DBTN132_n418
+ destinationAddressIn_WEST[6] AOI22X1TS
XU944 n443 FE_DBTN165_n2 destinationAddressIn_SOUTH[6] FE_DBTN162_n5
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU945 n1119 n1057 FE_DBTN197_destinationAddressInBuffer_EAST_6_ n444 n443
+ OAI211XLTS
XU948 n534 n1955 INVX2TS
XU949 n532 FE_DBTN128_n1961 n534 NAND2X1TS
XU950 n506 FE_DBTN128_n1961 n1956 n532 OAI21XLTS
XU953 n842 n532 FE_DBTN126_n1952 NOR2XLTS
XU956 n503 n532 FE_DBTN126_n1952 n842 AOI21X1TS
XU957 n448 FE_DBTN150_n1962 n506 FE_DBTN130_n1959 n503 OAI22X1TS
XU958 n452 n506 FE_DBTN150_n1962 FE_DBTN130_n1959 n503 n448 AOI221XLTS
XU960 n450 n1949 INVX2TS
XU961 n465 FE_DBTN137_n1958 n450 NAND2X1TS
XU962 n469 FE_DBTN137_n1958 n1961 n465 OAI21XLTS
XU963 n453 n452 n469 n1951 AOI21X1TS
XU964 n496 reset INVX2TS
XU965 n507 n496 n1951 NAND2X1TS
XU966 n501 reset FE_DBTN146_n186 NOR2XLTS
XU970 n459 FE_DBTN140_n1960 FE_DBTN126_n1952 FE_DBTN127_n1953 FE_DBTN130_n1959
+ AOI22X1TS
XU972 n476 n479 INVX2TS
XU973 n475 FE_DBTN128_n1961 FE_DBTN133_n1954 n461 AOI21X1TS
XU974 n479 n481 n468 n467 ADDHXLTS
XU975 n470 n481 INVX2TS
XU976 n473 n471 n470 n469 AOI21X1TS
XU977 n472 n471 n470 n477 n476 OAI22X1TS
XU978 n474 n480 n473 n472 AOI21X1TS
XU979 n478 n477 n476 n475 n474 AOI211X1TS
XU980 n482 n478 INVX2TS
XU981 n486 n482 n479 NAND2X1TS
XU982 n494 n500 INVX2TS
XU984 n490 n497 FE_DBTN137_n1958 n487 ADDHXLTS
XU985 n491 n1956 n498 XNOR2X1TS
XU986 N2624 n501 n495 n1963 n507 OAI2BB2XLTS
XU987 n505 n496 n1950 NAND2X1TS
XU988 n1336 n1949 n507 n505 n450 AOI22X1TS
XU989 n504 n503 INVX2TS
XU990 n1331 FE_DBTN126_n1952 n507 n504 n505 OAI22X1TS
XU991 n1330 n1955 n507 n506 n505 OAI22X1TS
XU997 n524 n1950 INVX2TS
XU998 n512 n542 n524 NAND2X1TS
XU999 n616 readReady selectBit_EAST n458 n512 NOR4XLTS
XU1003 n545 readIn_SOUTH n547 readIn_WEST n616 AOI22X1TS
XU1008 n649 selectBit_WEST readReady n516 n512 NOR4XLTS
XU1012 n544 readIn_NORTH n695 readIn_EAST n649 AOI22X1TS
XU1013 n520 selectBit_EAST readReady n458 NOR3XLTS
XU1014 n519 selectBit_WEST readReady n516 NOR3XLTS
XU1015 n523 n520 n541 n519 n542 OAI31X1TS
XU1016 n678 n524 n523 n522 n521 NAND4XLTS
XU1021 n723 FE_DBTN128_n1961 FE_DBTN127_n1953 n1955 NOR3XLTS
XU1024 n697 FE_DBTN128_n1961 n1956 FE_DBTN127_n1953 NOR3XLTS
XU1027 n539 readOutbuffer[2] n723 readOutbuffer[0] n697 AOI22X1TS
XU1028 n724 FE_DBTN128_n1961 n1955 FE_DBTN126_n1952 NOR3XLTS
XU1031 n698 FE_DBTN128_n1961 n534 FE_DBTN126_n1952 NOR3XLTS
XU1034 n538 readOutbuffer[6] n724 readOutbuffer[4] n698 AOI22X1TS
XU1035 n725 FE_DBTN127_n1953 n532 NOR2XLTS
XU1038 n699 n534 FE_DBTN127_n1953 n1961 NOR3XLTS
XU1041 n537 readOutbuffer[3] n725 readOutbuffer[1] n699 AOI22X1TS
XU1043 n865 n1956 n450 FE_DBTN126_n1952 NOR3XLTS
XU1046 n536 readOutbuffer[7] n842 readOutbuffer[5] n865 AOI22X1TS
XU1047 n540 n539 n538 n537 n536 NAND4XLTS
XU1048 n543 readOut n555 n1950 n540 AOI22X1TS
XU1050 n558 writeIn_EAST n649 writeIn_WEST n616 AOI22X1TS
XU1053 n557 writeIn_NORTH n695 writeIn_SOUTH n547 AOI22X1TS
XU1054 n553 writeOutbuffer[2] n723 writeOutbuffer[0] n697 AOI22X1TS
XU1055 n552 writeOutbuffer[6] n724 writeOutbuffer[4] n698 AOI22X1TS
XU1056 n551 writeOutbuffer[3] n725 writeOutbuffer[1] n699 AOI22X1TS
XU1057 n550 writeOutbuffer[7] n842 writeOutbuffer[5] n865 AOI22X1TS
XU1058 n554 n553 n552 n551 n550 NAND4XLTS
XU1059 n556 writeOut n555 n1950 n554 AOI22X1TS
XU1065 n567 requesterAddressIn_NORTH[0] n695 requesterAddressIn_EAST[0] n649
+ AOI22X1TS
XU1071 n566 requesterAddressIn_SOUTH[0] n547 requesterAddressIn_WEST[0] n616
+ AOI22X1TS
XU1074 n562 requesterAddressbuffer[2][0] n723 requesterAddressbuffer[0][0] n697
+ AOI22X1TS
XU1075 n561 requesterAddressbuffer[6][0] n724 requesterAddressbuffer[4][0] n698
+ AOI22X1TS
XU1076 n560 requesterAddressbuffer[3][0] n725 requesterAddressbuffer[1][0] n699
+ AOI22X1TS
XU1079 n559 requesterAddressbuffer[7][0] n842 requesterAddressbuffer[5][0] n865
+ AOI22X1TS
XU1080 n563 n562 n561 n560 n559 NAND4XLTS
XU1081 n565 requesterAddressOut[0] FE_DBTN129_n678 n1950 n563 AOI22X1TS
XU1085 n611 readRequesterAddress[0] FE_DBTN125_n564 NAND2X1TS
XU1090 n584 requesterAddressIn_NORTH[1] n695 requesterAddressIn_EAST[1] n649
+ AOI22X1TS
XU1096 n583 requesterAddressIn_SOUTH[1] n547 requesterAddressIn_WEST[1] n616
+ AOI22X1TS
XU1097 n580 requesterAddressbuffer[2][1] n723 requesterAddressbuffer[0][1] n697
+ AOI22X1TS
XU1098 n579 requesterAddressbuffer[6][1] n724 requesterAddressbuffer[4][1] n698
+ AOI22X1TS
XU1099 n578 requesterAddressbuffer[3][1] n725 requesterAddressbuffer[1][1] n699
+ AOI22X1TS
XU1100 n577 requesterAddressbuffer[7][1] n842 requesterAddressbuffer[5][1] n865
+ AOI22X1TS
XU1101 n581 n580 n579 n578 n577 NAND4XLTS
XU1102 n582 requesterAddressOut[1] FE_DBTN129_n678 n1950 n581 AOI22X1TS
XU1105 n626 readRequesterAddress[1] FE_DBTN125_n564 NAND2X1TS
XU1111 n592 requesterAddressIn_NORTH[2] n695 requesterAddressIn_EAST[2] n649
+ AOI22X1TS
XU1116 n591 requesterAddressIn_SOUTH[2] n547 requesterAddressIn_WEST[2] n616
+ AOI22X1TS
XU1119 n588 requesterAddressbuffer[2][2] n723 requesterAddressbuffer[0][2] n697
+ AOI22X1TS
XU1121 n587 requesterAddressbuffer[6][2] n724 requesterAddressbuffer[4][2] n698
+ AOI22X1TS
XU1123 n586 requesterAddressbuffer[3][2] n725 requesterAddressbuffer[1][2] n699
+ AOI22X1TS
XU1125 n585 requesterAddressbuffer[7][2] n842 requesterAddressbuffer[5][2] n865
+ AOI22X1TS
XU1126 n589 n588 n587 n586 n585 NAND4XLTS
XU1127 n590 requesterAddressOut[2] FE_DBTN129_n678 n1950 n589 AOI22X1TS
XU1130 n645 readRequesterAddress[2] FE_DBTN125_n564 NAND2X1TS
XU1135 n603 requesterAddressIn_NORTH[3] n695 requesterAddressIn_EAST[3] n649
+ AOI22X1TS
XU1140 n602 requesterAddressIn_SOUTH[3] n547 requesterAddressIn_WEST[3] n616
+ AOI22X1TS
XU1141 n597 requesterAddressbuffer[2][3] n723 requesterAddressbuffer[0][3] n697
+ AOI22X1TS
XU1142 n596 requesterAddressbuffer[6][3] n724 requesterAddressbuffer[4][3] n698
+ AOI22X1TS
XU1143 n595 requesterAddressbuffer[3][3] n725 requesterAddressbuffer[1][3] n699
+ AOI22X1TS
XU1145 n594 requesterAddressbuffer[7][3] n842 requesterAddressbuffer[5][3] n865
+ AOI22X1TS
XU1146 n598 n597 n596 n595 n594 NAND4XLTS
XU1147 n601 requesterAddressOut[3] FE_DBTN129_n678 n1950 n598 AOI22X1TS
XU1150 n657 readRequesterAddress[3] FE_DBTN125_n564 NAND2X1TS
XU1154 n614 destinationAddressIn_NORTH[0] n695 destinationAddressIn_EAST[0]
+ n649 AOI22X1TS
XU1157 n613 destinationAddressIn_SOUTH[0] n547 destinationAddressIn_WEST[0]
+ n616 AOI22X1TS
XU1159 n609 destinationAddressbuffer[2][0] n723 destinationAddressbuffer[0][0]
+ n697 AOI22X1TS
XU1160 n608 destinationAddressbuffer[6][0] n724 destinationAddressbuffer[4][0]
+ n698 AOI22X1TS
XU1161 n607 destinationAddressbuffer[3][0] n725 destinationAddressbuffer[1][0]
+ n699 AOI22X1TS
XU1162 n606 destinationAddressbuffer[7][0] n842 destinationAddressbuffer[5][0]
+ n865 AOI22X1TS
XU1163 n610 n609 n608 n607 n606 NAND4XLTS
XU1164 n612 destinationAddressOut[0] FE_DBTN129_n678 n1950 n610 AOI22X1TS
XU1168 n629 destinationAddressIn_NORTH[1] n695 destinationAddressIn_EAST[1]
+ n649 AOI22X1TS
XU1171 n628 destinationAddressIn_SOUTH[1] n547 destinationAddressIn_WEST[1]
+ n616 AOI22X1TS
XU1172 n624 destinationAddressbuffer[2][1] n723 destinationAddressbuffer[0][1]
+ n697 AOI22X1TS
XU1173 n623 destinationAddressbuffer[6][1] n724 destinationAddressbuffer[4][1]
+ n698 AOI22X1TS
XU1174 n622 destinationAddressbuffer[3][1] n725 destinationAddressbuffer[1][1]
+ n699 AOI22X1TS
XU1175 n621 destinationAddressbuffer[7][1] n842 destinationAddressbuffer[5][1]
+ n865 AOI22X1TS
XU1176 n625 n624 n623 n622 n621 NAND4XLTS
XU1177 n627 destinationAddressOut[1] FE_DBTN129_n678 n1950 n625 AOI22X1TS
XU1182 n648 destinationAddressIn_NORTH[2] n695 destinationAddressIn_EAST[2]
+ n649 AOI22X1TS
XU1187 n647 destinationAddressIn_SOUTH[2] n547 destinationAddressIn_WEST[2]
+ n616 AOI22X1TS
XU1191 n643 destinationAddressbuffer[2][2] n723 destinationAddressbuffer[0][2]
+ n697 AOI22X1TS
XU1194 n642 destinationAddressbuffer[6][2] n724 destinationAddressbuffer[4][2]
+ n698 AOI22X1TS
XU1197 n641 destinationAddressbuffer[3][2] n725 destinationAddressbuffer[1][2]
+ n699 AOI22X1TS
XU1199 n640 destinationAddressbuffer[7][2] n842 destinationAddressbuffer[5][2]
+ n865 AOI22X1TS
XU1200 n644 n643 n642 n641 n640 NAND4XLTS
XU1201 n646 destinationAddressOut[2] FE_DBTN129_n678 n1950 n644 AOI22X1TS
XU1205 n660 destinationAddressIn_NORTH[3] n695 destinationAddressIn_EAST[3]
+ n649 AOI22X1TS
XU1208 n659 destinationAddressIn_SOUTH[3] n547 destinationAddressIn_WEST[3]
+ n616 AOI22X1TS
XU1209 n654 destinationAddressbuffer[2][3] n723 destinationAddressbuffer[0][3]
+ n697 AOI22X1TS
XU1210 n653 destinationAddressbuffer[6][3] n724 destinationAddressbuffer[4][3]
+ n698 AOI22X1TS
XU1211 n652 destinationAddressbuffer[3][3] n725 destinationAddressbuffer[1][3]
+ n699 AOI22X1TS
XU1212 n651 destinationAddressbuffer[7][3] n842 destinationAddressbuffer[5][3]
+ n865 AOI22X1TS
XU1213 n655 n654 n653 n652 n651 NAND4XLTS
XU1214 n658 destinationAddressOut[3] FE_DBTN129_n678 n1950 n655 AOI22X1TS
XU1215 n671 destinationAddressIn_EAST[4] n649 destinationAddressIn_WEST[4] n616
+ AOI22X1TS
XU1216 n670 destinationAddressIn_NORTH[4] n695 destinationAddressIn_SOUTH[4]
+ n547 AOI22X1TS
XU1217 n772 n1951 INVX2TS
XU1219 n667 destinationAddressbuffer[2][4] n723 destinationAddressbuffer[0][4]
+ n697 AOI22X1TS
XU1220 n666 destinationAddressbuffer[6][4] n724 destinationAddressbuffer[4][4]
+ n698 AOI22X1TS
XU1221 n665 destinationAddressbuffer[3][4] n725 destinationAddressbuffer[1][4]
+ n699 AOI22X1TS
XU1223 n664 destinationAddressbuffer[7][4] n842 destinationAddressbuffer[5][4]
+ n865 AOI22X1TS
XU1224 n668 n667 n666 n665 n664 NAND4XLTS
XU1225 n669 destinationAddressOut[4] FE_DBTN129_n678 n772 n668 AOI22X1TS
XU1227 n693 destinationAddressIn_EAST[5] n649 destinationAddressIn_WEST[5] n616
+ AOI22X1TS
XU1229 n692 destinationAddressIn_NORTH[5] n695 destinationAddressIn_SOUTH[5]
+ n547 AOI22X1TS
XU1231 n689 destinationAddressbuffer[2][5] n723 destinationAddressbuffer[0][5]
+ n697 AOI22X1TS
XU1232 n688 destinationAddressbuffer[6][5] n724 destinationAddressbuffer[4][5]
+ n698 AOI22X1TS
XU1233 n687 destinationAddressbuffer[3][5] n725 destinationAddressbuffer[1][5]
+ n699 AOI22X1TS
XU1234 n686 destinationAddressbuffer[7][5] n842 destinationAddressbuffer[5][5]
+ n865 AOI22X1TS
XU1235 n690 n689 n688 n687 n686 NAND4XLTS
XU1236 n691 destinationAddressOut[5] FE_DBTN129_n678 n772 n690 AOI22X1TS
XU1238 n708 destinationAddressIn_EAST[6] n649 destinationAddressIn_WEST[6] n616
+ AOI22X1TS
XU1240 n707 destinationAddressIn_NORTH[6] n695 destinationAddressIn_SOUTH[6]
+ n547 AOI22X1TS
XU1243 n703 destinationAddressbuffer[2][6] n723 destinationAddressbuffer[0][6]
+ n697 AOI22X1TS
XU1246 n702 destinationAddressbuffer[6][6] n724 destinationAddressbuffer[4][6]
+ n698 AOI22X1TS
XU1249 n701 destinationAddressbuffer[3][6] n725 destinationAddressbuffer[1][6]
+ n699 AOI22X1TS
XU1252 n700 destinationAddressbuffer[7][6] n842 destinationAddressbuffer[5][6]
+ n865 AOI22X1TS
XU1253 n704 n703 n702 n701 n700 NAND4XLTS
XU1254 n706 destinationAddressOut[6] FE_DBTN129_n678 n772 n704 AOI22X1TS
XU1255 n719 destinationAddressIn_EAST[7] n649 destinationAddressIn_WEST[7] n616
+ AOI22X1TS
XU1256 n718 destinationAddressIn_NORTH[7] n695 destinationAddressIn_SOUTH[7]
+ n547 AOI22X1TS
XU1258 n715 destinationAddressbuffer[2][7] n723 destinationAddressbuffer[0][7]
+ n697 AOI22X1TS
XU1259 n714 destinationAddressbuffer[6][7] n724 destinationAddressbuffer[4][7]
+ n698 AOI22X1TS
XU1260 n713 destinationAddressbuffer[3][7] n725 destinationAddressbuffer[1][7]
+ n699 AOI22X1TS
XU1261 n712 destinationAddressbuffer[7][7] n842 destinationAddressbuffer[5][7]
+ n865 AOI22X1TS
XU1262 n716 n715 n714 n713 n712 NAND4XLTS
XU1263 n717 destinationAddressOut[7] FE_DBTN129_n678 n772 n716 AOI22X1TS
XU1264 n733 destinationAddressIn_EAST[8] n649 destinationAddressIn_WEST[8] n616
+ AOI22X1TS
XU1265 n732 destinationAddressIn_NORTH[8] n695 destinationAddressIn_SOUTH[8]
+ n547 AOI22X1TS
XU1267 n729 destinationAddressbuffer[2][8] n723 destinationAddressbuffer[0][8]
+ n697 AOI22X1TS
XU1269 n728 destinationAddressbuffer[6][8] n724 destinationAddressbuffer[4][8]
+ n698 AOI22X1TS
XU1271 n727 destinationAddressbuffer[3][8] n725 destinationAddressbuffer[1][8]
+ n699 AOI22X1TS
XU1272 n726 destinationAddressbuffer[7][8] n842 destinationAddressbuffer[5][8]
+ n865 AOI22X1TS
XU1273 n730 n729 n728 n727 n726 NAND4XLTS
XU1274 n731 destinationAddressOut[8] FE_DBTN129_n678 n772 n730 AOI22X1TS
XU1275 n751 destinationAddressIn_EAST[9] n649 destinationAddressIn_WEST[9] n616
+ AOI22X1TS
XU1276 n750 destinationAddressIn_NORTH[9] n695 destinationAddressIn_SOUTH[9]
+ n547 AOI22X1TS
XU1277 n746 destinationAddressbuffer[2][9] n723 destinationAddressbuffer[0][9]
+ n697 AOI22X1TS
XU1278 n745 destinationAddressbuffer[6][9] n724 destinationAddressbuffer[4][9]
+ n698 AOI22X1TS
XU1279 n744 destinationAddressbuffer[3][9] n725 destinationAddressbuffer[1][9]
+ n699 AOI22X1TS
XU1280 n743 destinationAddressbuffer[7][9] n842 destinationAddressbuffer[5][9]
+ n865 AOI22X1TS
XU1281 n747 n746 n745 n744 n743 NAND4XLTS
XU1282 n749 destinationAddressOut[9] FE_DBTN129_n678 n772 n747 AOI22X1TS
XU1284 n766 destinationAddressIn_EAST[10] n649 destinationAddressIn_WEST[10]
+ n616 AOI22X1TS
XU1286 n765 destinationAddressIn_NORTH[10] n695 destinationAddressIn_SOUTH[10]
+ n547 AOI22X1TS
XU1289 n761 destinationAddressbuffer[2][10] n723
+ destinationAddressbuffer[0][10] n697 AOI22X1TS
XU1292 n760 destinationAddressbuffer[6][10] n724
+ destinationAddressbuffer[4][10] n698 AOI22X1TS
XU1295 n759 destinationAddressbuffer[3][10] n725
+ destinationAddressbuffer[1][10] n699 AOI22X1TS
XU1297 n758 destinationAddressbuffer[7][10] n842
+ destinationAddressbuffer[5][10] n865 AOI22X1TS
XU1298 n762 n761 n760 n759 n758 NAND4XLTS
XU1299 n764 destinationAddressOut[10] FE_DBTN129_n678 n772 n762 AOI22X1TS
XU1300 n780 destinationAddressIn_EAST[11] n649 destinationAddressIn_WEST[11]
+ n616 AOI22X1TS
XU1301 n779 destinationAddressIn_NORTH[11] n695 destinationAddressIn_SOUTH[11]
+ n547 AOI22X1TS
XU1303 n776 destinationAddressbuffer[2][11] n723
+ destinationAddressbuffer[0][11] n697 AOI22X1TS
XU1304 n775 destinationAddressbuffer[6][11] n724
+ destinationAddressbuffer[4][11] n698 AOI22X1TS
XU1305 n774 destinationAddressbuffer[3][11] n725
+ destinationAddressbuffer[1][11] n699 AOI22X1TS
XU1306 n773 destinationAddressbuffer[7][11] n842
+ destinationAddressbuffer[5][11] n865 AOI22X1TS
XU1307 n777 n776 n775 n774 n773 NAND4XLTS
XU1308 n778 destinationAddressOut[11] FE_DBTN129_n678 n772 n777 AOI22X1TS
XU1313 n790 dataIn_NORTH[0] n695 dataIn_EAST[0] n649 AOI22X1TS
XU1316 n789 dataIn_SOUTH[0] n547 dataIn_WEST[0] n616 AOI22X1TS
XU1317 n785 dataoutbuffer[0][0] n697 dataoutbuffer[2][0] n723 AOI22X1TS
XU1318 n784 dataoutbuffer[4][0] n698 dataoutbuffer[6][0] n724 AOI22X1TS
XU1319 n783 dataoutbuffer[1][0] n699 dataoutbuffer[3][0] n725 AOI22X1TS
XU1320 n782 dataoutbuffer[5][0] n865 dataoutbuffer[7][0] n842 AOI22X1TS
XU1321 n786 n785 n784 n783 n782 NAND4XLTS
XU1322 n788 dataOut[0] FE_DBTN129_n678 n772 n786 AOI22X1TS
XU1325 n787 cacheDataOut[0] FE_DBTN125_n564 NAND2X1TS
XU1329 n810 dataIn_NORTH[1] n695 dataIn_EAST[1] n649 AOI22X1TS
XU1332 n809 dataIn_SOUTH[1] n547 dataIn_WEST[1] n616 AOI22X1TS
XU1333 n805 dataoutbuffer[0][1] n697 dataoutbuffer[2][1] n723 AOI22X1TS
XU1334 n804 dataoutbuffer[4][1] n698 dataoutbuffer[6][1] n724 AOI22X1TS
XU1335 n803 dataoutbuffer[1][1] n699 dataoutbuffer[3][1] n725 AOI22X1TS
XU1336 n802 dataoutbuffer[5][1] n865 dataoutbuffer[7][1] n842 AOI22X1TS
XU1337 n806 n805 n804 n803 n802 NAND4XLTS
XU1338 n808 dataOut[1] FE_DBTN129_n678 n772 n806 AOI22X1TS
XU1341 n807 cacheDataOut[1] FE_DBTN125_n564 NAND2X1TS
XU1346 n829 dataIn_NORTH[2] n695 dataIn_EAST[2] n649 AOI22X1TS
XU1350 n828 dataIn_SOUTH[2] n547 dataIn_WEST[2] n616 AOI22X1TS
XU1353 n823 dataoutbuffer[0][2] n697 dataoutbuffer[2][2] n723 AOI22X1TS
XU1356 n822 dataoutbuffer[4][2] n698 dataoutbuffer[6][2] n724 AOI22X1TS
XU1359 n821 dataoutbuffer[1][2] n699 dataoutbuffer[3][2] n725 AOI22X1TS
XU1360 n820 dataoutbuffer[5][2] n865 dataoutbuffer[7][2] n842 AOI22X1TS
XU1361 n824 n823 n822 n821 n820 NAND4XLTS
XU1362 n827 dataOut[2] FE_DBTN129_n678 n772 n824 AOI22X1TS
XU1364 n826 cacheDataOut[2] FE_DBTN125_n564 NAND2X1TS
XU1368 n841 dataIn_NORTH[3] n695 dataIn_EAST[3] n649 AOI22X1TS
XU1371 n840 dataIn_SOUTH[3] n547 dataIn_WEST[3] n616 AOI22X1TS
XU1372 n835 dataoutbuffer[0][3] n697 dataoutbuffer[2][3] n723 AOI22X1TS
XU1373 n834 dataoutbuffer[4][3] n698 dataoutbuffer[6][3] n724 AOI22X1TS
XU1374 n833 dataoutbuffer[1][3] n699 dataoutbuffer[3][3] n725 AOI22X1TS
XU1375 n832 dataoutbuffer[5][3] n865 dataoutbuffer[7][3] n842 AOI22X1TS
XU1376 n836 n835 n834 n833 n832 NAND4XLTS
XU1377 n839 dataOut[3] FE_DBTN129_n678 n1950 n836 AOI22X1TS
XU1379 n838 cacheDataOut[3] FE_DBTN125_n564 NAND2X1TS
XU1383 n853 dataIn_NORTH[4] n695 dataIn_EAST[4] n649 AOI22X1TS
XU1386 n852 dataIn_SOUTH[4] n547 dataIn_WEST[4] n616 AOI22X1TS
XU1387 n846 dataoutbuffer[0][4] n697 dataoutbuffer[2][4] n723 AOI22X1TS
XU1388 n845 dataoutbuffer[4][4] n698 dataoutbuffer[6][4] n724 AOI22X1TS
XU1389 n844 dataoutbuffer[1][4] n699 dataoutbuffer[3][4] n725 AOI22X1TS
XU1390 n843 dataoutbuffer[5][4] n865 dataoutbuffer[7][4] n842 AOI22X1TS
XU1391 n847 n846 n845 n844 n843 NAND4XLTS
XU1392 n851 dataOut[4] FE_DBTN129_n678 n1950 n847 AOI22X1TS
XU1394 n850 cacheDataOut[4] FE_DBTN125_n564 NAND2X1TS
XU1398 n877 dataIn_NORTH[5] n695 dataIn_EAST[5] n649 AOI22X1TS
XU1401 n876 dataIn_SOUTH[5] n547 dataIn_WEST[5] n616 AOI22X1TS
XU1402 n869 dataoutbuffer[0][5] n697 dataoutbuffer[2][5] n723 AOI22X1TS
XU1403 n868 dataoutbuffer[4][5] n698 dataoutbuffer[6][5] n724 AOI22X1TS
XU1404 n867 dataoutbuffer[1][5] n699 dataoutbuffer[3][5] n725 AOI22X1TS
XU1405 n866 dataoutbuffer[5][5] n865 dataoutbuffer[7][5] n842 AOI22X1TS
XU1406 n870 n869 n868 n867 n866 NAND4XLTS
XU1407 n875 dataOut[5] FE_DBTN129_n678 n772 n870 AOI22X1TS
XU1409 n874 cacheDataOut[5] FE_DBTN125_n564 NAND2X1TS
XU1412 n881 readRequesterAddress[0] n36 FE_DBTN152_n1547
+ requesterAddressbuffer[7][0] AOI22X1TS
XU1414 n880 FE_DBTN153_n57 requesterAddressIn_WEST[0] n34
+ requesterAddressIn_EAST[0] AOI22X1TS
XU1417 n879 FE_DBTN164_n3 requesterAddressIn_SOUTH[0] FE_DBTN151_n62
+ requesterAddressIn_NORTH[0] AOI22X1TS
XU1419 n885 n36 readRequesterAddress[1] FE_DBTN152_n1547
+ requesterAddressbuffer[7][1] AOI22X1TS
XU1421 n884 FE_DBTN153_n57 requesterAddressIn_WEST[1] n34
+ requesterAddressIn_EAST[1] AOI22X1TS
XU1423 n883 FE_DBTN164_n3 requesterAddressIn_SOUTH[1] FE_DBTN151_n62
+ requesterAddressIn_NORTH[1] AOI22X1TS
XU1426 n888 n36 readRequesterAddress[2] FE_DBTN152_n1547
+ requesterAddressbuffer[7][2] AOI22X1TS
XU1428 n887 FE_DBTN153_n57 requesterAddressIn_WEST[2] n34
+ requesterAddressIn_EAST[2] AOI22X1TS
XU1430 n886 FE_DBTN164_n3 requesterAddressIn_SOUTH[2] FE_DBTN151_n62
+ requesterAddressIn_NORTH[2] AOI22X1TS
XU1431 n894 n36 readRequesterAddress[3] FE_DBTN152_n1547
+ requesterAddressbuffer[7][3] AOI22X1TS
XU1432 n893 FE_DBTN153_n57 requesterAddressIn_WEST[3] n34
+ requesterAddressIn_EAST[3] AOI22X1TS
XU1434 n892 FE_DBTN164_n3 requesterAddressIn_SOUTH[3] FE_DBTN151_n62
+ requesterAddressIn_NORTH[3] AOI22X1TS
XU1437 n897 readRequesterAddress[0] FE_DBTN158_n10 FE_DBTN148_n1496
+ requesterAddressbuffer[6][0] AOI22X1TS
XU1439 n896 requesterAddressIn_WEST[0] FE_DBTN149_n106
+ requesterAddressIn_EAST[0] n85 AOI22X1TS
XU1440 n895 requesterAddressIn_SOUTH[0] n92 requesterAddressIn_NORTH[0]
+ FE_DBTN160_n7 AOI22X1TS
XU1442 n902 readRequesterAddress[1] FE_DBTN158_n10 FE_DBTN148_n1496
+ requesterAddressbuffer[6][1] AOI22X1TS
XU1444 n901 requesterAddressIn_WEST[1] FE_DBTN149_n106
+ requesterAddressIn_EAST[1] n85 AOI22X1TS
XU1447 n900 requesterAddressIn_SOUTH[1] n92 requesterAddressIn_NORTH[1]
+ FE_DBTN160_n7 AOI22X1TS
XU1451 n906 readRequesterAddress[2] FE_DBTN158_n10 FE_DBTN148_n1496
+ requesterAddressbuffer[6][2] AOI22X1TS
XU1452 n905 requesterAddressIn_WEST[2] FE_DBTN149_n106
+ requesterAddressIn_EAST[2] n85 AOI22X1TS
XU1453 n904 requesterAddressIn_SOUTH[2] n92 requesterAddressIn_NORTH[2]
+ FE_DBTN160_n7 AOI22X1TS
XU1456 n912 readRequesterAddress[3] FE_DBTN158_n10 FE_DBTN148_n1496
+ requesterAddressbuffer[6][3] AOI22X1TS
XU1458 n911 requesterAddressIn_WEST[3] FE_DBTN149_n106
+ requesterAddressIn_EAST[3] n85 AOI22X1TS
XU1460 n910 requesterAddressIn_SOUTH[3] n92 requesterAddressIn_NORTH[3]
+ FE_DBTN160_n7 AOI22X1TS
XU1462 n916 readRequesterAddress[0] FE_DBTN157_n11 FE_DBTN141_n1460
+ requesterAddressbuffer[5][0] AOI22X1TS
XU1464 n915 requesterAddressIn_WEST[0] FE_DBTN143_n243
+ requesterAddressIn_EAST[0] n225 AOI22X1TS
XU1466 n914 requesterAddressIn_SOUTH[0] FE_DBTN142_n250
+ requesterAddressIn_NORTH[0] n230 AOI22X1TS
XU1467 n921 readRequesterAddress[1] FE_DBTN157_n11 FE_DBTN141_n1460
+ requesterAddressbuffer[5][1] AOI22X1TS
XU1469 n920 requesterAddressIn_WEST[1] FE_DBTN143_n243
+ requesterAddressIn_EAST[1] n225 AOI22X1TS
XU1470 n919 requesterAddressIn_SOUTH[1] FE_DBTN142_n250
+ requesterAddressIn_NORTH[1] n230 AOI22X1TS
XU1473 n925 readRequesterAddress[2] FE_DBTN157_n11 FE_DBTN141_n1460
+ requesterAddressbuffer[5][2] AOI22X1TS
XU1474 n924 requesterAddressIn_WEST[2] FE_DBTN143_n243
+ requesterAddressIn_EAST[2] n225 AOI22X1TS
XU1475 n923 requesterAddressIn_SOUTH[2] FE_DBTN142_n250
+ requesterAddressIn_NORTH[2] n230 AOI22X1TS
XU1477 n929 readRequesterAddress[3] FE_DBTN157_n11 FE_DBTN141_n1460
+ requesterAddressbuffer[5][3] AOI22X1TS
XU1478 n928 requesterAddressIn_WEST[3] FE_DBTN143_n243
+ requesterAddressIn_EAST[3] n225 AOI22X1TS
XU1479 n927 requesterAddressIn_SOUTH[3] FE_DBTN142_n250
+ requesterAddressIn_NORTH[3] n230 AOI22X1TS
XU1481 n935 readRequesterAddress[0] FE_DBTN156_n12 FE_DBTN138_n1429
+ requesterAddressbuffer[4][0] AOI22X1TS
XU1483 n934 requesterAddressIn_WEST[0] FE_DBTN139_n293
+ requesterAddressIn_EAST[0] n278 AOI22X1TS
XU1484 n933 requesterAddressIn_SOUTH[0] FE_DBTN166_n1
+ requesterAddressIn_NORTH[0] FE_DBTN161_n6 AOI22X1TS
XU1486 n941 readRequesterAddress[1] FE_DBTN156_n12 FE_DBTN138_n1429
+ requesterAddressbuffer[4][1] AOI22X1TS
XU1488 n940 requesterAddressIn_WEST[1] FE_DBTN139_n293
+ requesterAddressIn_EAST[1] n278 AOI22X1TS
XU1489 n939 requesterAddressIn_SOUTH[1] FE_DBTN166_n1
+ requesterAddressIn_NORTH[1] FE_DBTN161_n6 AOI22X1TS
XU1493 n946 readRequesterAddress[2] FE_DBTN156_n12 FE_DBTN138_n1429
+ requesterAddressbuffer[4][2] AOI22X1TS
XU1494 n945 requesterAddressIn_WEST[2] FE_DBTN139_n293
+ requesterAddressIn_EAST[2] n278 AOI22X1TS
XU1495 n944 requesterAddressIn_SOUTH[2] FE_DBTN166_n1
+ requesterAddressIn_NORTH[2] FE_DBTN161_n6 AOI22X1TS
XU1498 n954 readRequesterAddress[3] FE_DBTN156_n12 FE_DBTN138_n1429
+ requesterAddressbuffer[4][3] AOI22X1TS
XU1500 n953 requesterAddressIn_WEST[3] FE_DBTN139_n293
+ requesterAddressIn_EAST[3] n278 AOI22X1TS
XU1501 n952 requesterAddressIn_SOUTH[3] FE_DBTN166_n1
+ requesterAddressIn_NORTH[3] FE_DBTN161_n6 AOI22X1TS
XU1504 n960 readRequesterAddress[0] n131 FE_DBTN147_n1397
+ requesterAddressbuffer[3][0] AOI22X1TS
XU1506 n959 requesterAddressIn_WEST[0] n135 requesterAddressIn_EAST[0] n139
+ AOI22X1TS
XU1508 n958 requesterAddressIn_SOUTH[0] n130 requesterAddressIn_NORTH[0] n140
+ AOI22X1TS
XU1510 n967 readRequesterAddress[1] n131 FE_DBTN147_n1397
+ requesterAddressbuffer[3][1] AOI22X1TS
XU1512 n966 requesterAddressIn_WEST[1] n135 requesterAddressIn_EAST[1] n139
+ AOI22X1TS
XU1513 n965 requesterAddressIn_SOUTH[1] n130 requesterAddressIn_NORTH[1] n140
+ AOI22X1TS
XU1517 n974 readRequesterAddress[2] n131 FE_DBTN147_n1397
+ requesterAddressbuffer[3][2] AOI22X1TS
XU1518 n973 requesterAddressIn_WEST[2] n135 requesterAddressIn_EAST[2] n139
+ AOI22X1TS
XU1520 n972 requesterAddressIn_SOUTH[2] n130 requesterAddressIn_NORTH[2] n140
+ AOI22X1TS
XU1522 n979 readRequesterAddress[3] n131 FE_DBTN147_n1397
+ requesterAddressbuffer[3][3] AOI22X1TS
XU1523 n978 requesterAddressIn_WEST[3] n135 requesterAddressIn_EAST[3] n139
+ AOI22X1TS
XU1524 n977 requesterAddressIn_SOUTH[3] n130 requesterAddressIn_NORTH[3] n140
+ AOI22X1TS
XU1526 n983 readRequesterAddress[0] FE_DBTN155_n13 FE_DBTN144_n1362
+ requesterAddressbuffer[2][0] AOI22X1TS
XU1528 n982 requesterAddressIn_WEST[0] FE_DBTN145_n202
+ requesterAddressIn_EAST[0] n185 AOI22X1TS
XU1530 n981 requesterAddressIn_SOUTH[0] n192 requesterAddressIn_NORTH[0]
+ FE_DBTN163_n4 AOI22X1TS
XU1531 n988 readRequesterAddress[1] FE_DBTN155_n13 FE_DBTN144_n1362
+ requesterAddressbuffer[2][1] AOI22X1TS
XU1533 n987 requesterAddressIn_WEST[1] FE_DBTN145_n202
+ requesterAddressIn_EAST[1] n185 AOI22X1TS
XU1536 n986 requesterAddressIn_SOUTH[1] n192 requesterAddressIn_NORTH[1]
+ FE_DBTN163_n4 AOI22X1TS
XU1539 n991 readRequesterAddress[2] FE_DBTN155_n13 FE_DBTN144_n1362
+ requesterAddressbuffer[2][2] AOI22X1TS
XU1540 n990 requesterAddressIn_WEST[2] FE_DBTN145_n202
+ requesterAddressIn_EAST[2] n185 AOI22X1TS
XU1541 n989 requesterAddressIn_SOUTH[2] n192 requesterAddressIn_NORTH[2]
+ FE_DBTN163_n4 AOI22X1TS
XU1543 n996 readRequesterAddress[3] FE_DBTN155_n13 FE_DBTN144_n1362
+ requesterAddressbuffer[2][3] AOI22X1TS
XU1545 n995 requesterAddressIn_WEST[3] FE_DBTN145_n202
+ requesterAddressIn_EAST[3] n185 AOI22X1TS
XU1546 n994 requesterAddressIn_SOUTH[3] n192 requesterAddressIn_NORTH[3]
+ FE_DBTN163_n4 AOI22X1TS
XU1548 n1003 readRequesterAddress[0] n320 FE_DBTN135_n359
+ requesterAddressbuffer[1][0] AOI22X1TS
XU1550 n1002 requesterAddressIn_WEST[0] FE_DBTN136_n346
+ requesterAddressIn_EAST[0] n318 AOI22X1TS
XU1551 n1001 requesterAddressIn_SOUTH[0] n326 requesterAddressIn_NORTH[0] n333
+ AOI22X1TS
XU1552 n1010 readRequesterAddress[1] n320 FE_DBTN135_n359
+ requesterAddressbuffer[1][1] AOI22X1TS
XU1554 n1009 requesterAddressIn_WEST[1] FE_DBTN136_n346
+ requesterAddressIn_EAST[1] n318 AOI22X1TS
XU1555 n1008 requesterAddressIn_SOUTH[1] n326 requesterAddressIn_NORTH[1] n333
+ AOI22X1TS
XU1558 n1018 readRequesterAddress[2] n320 FE_DBTN135_n359
+ requesterAddressbuffer[1][2] AOI22X1TS
XU1559 n1017 requesterAddressIn_WEST[2] FE_DBTN136_n346
+ requesterAddressIn_EAST[2] n318 AOI22X1TS
XU1560 n1016 requesterAddressIn_SOUTH[2] n326 requesterAddressIn_NORTH[2] n333
+ AOI22X1TS
XU1562 n1027 readRequesterAddress[3] n320 FE_DBTN135_n359
+ requesterAddressbuffer[1][3] AOI22X1TS
XU1564 n1026 requesterAddressIn_WEST[3] FE_DBTN136_n346
+ requesterAddressIn_EAST[3] n318 AOI22X1TS
XU1566 n1025 requesterAddressIn_SOUTH[3] n326 requesterAddressIn_NORTH[3] n333
+ AOI22X1TS
XU1568 n1034 readRequesterAddress[0] FE_DBTN154_n14 FE_DBTN131_n428
+ requesterAddressbuffer[0][0] AOI22X1TS
XU1570 n1033 requesterAddressIn_WEST[0] FE_DBTN132_n418
+ requesterAddressIn_EAST[0] n396 AOI22X1TS
XU1572 n1032 requesterAddressIn_SOUTH[0] FE_DBTN165_n2
+ requesterAddressIn_NORTH[0] FE_DBTN162_n5 AOI22X1TS
XU1573 n1041 readRequesterAddress[1] FE_DBTN154_n14 FE_DBTN131_n428
+ requesterAddressbuffer[0][1] AOI22X1TS
XU1575 n1040 requesterAddressIn_WEST[1] FE_DBTN132_n418
+ requesterAddressIn_EAST[1] n396 AOI22X1TS
XU1576 n1039 requesterAddressIn_SOUTH[1] FE_DBTN165_n2
+ requesterAddressIn_NORTH[1] FE_DBTN162_n5 AOI22X1TS
XU1579 n1047 readRequesterAddress[2] FE_DBTN154_n14 FE_DBTN131_n428
+ requesterAddressbuffer[0][2] AOI22X1TS
XU1580 n1046 requesterAddressIn_WEST[2] FE_DBTN132_n418
+ requesterAddressIn_EAST[2] n396 AOI22X1TS
XU1581 n1045 requesterAddressIn_SOUTH[2] FE_DBTN165_n2
+ requesterAddressIn_NORTH[2] FE_DBTN162_n5 AOI22X1TS
XU1583 n1056 readRequesterAddress[3] FE_DBTN154_n14 FE_DBTN131_n428
+ requesterAddressbuffer[0][3] AOI22X1TS
XU1585 n1055 requesterAddressIn_WEST[3] FE_DBTN132_n418
+ requesterAddressIn_EAST[3] n396 AOI22X1TS
XU1587 n1054 requesterAddressIn_SOUTH[3] FE_DBTN165_n2
+ requesterAddressIn_NORTH[3] FE_DBTN162_n5 AOI22X1TS
XU1590 n1062 FE_DBTN154_n14 cacheDataOut[0] FE_DBTN131_n428 dataoutbuffer[0][0]
+ AOI22X1TS
XU1591 n1061 FE_DBTN132_n418 dataIn_WEST[0] n396 dataIn_EAST[0] AOI22X1TS
XU1593 n1060 FE_DBTN165_n2 dataIn_SOUTH[0] FE_DBTN162_n5 dataIn_NORTH[0]
+ AOI22X1TS
XU1595 n1067 FE_DBTN154_n14 cacheDataOut[1] FE_DBTN131_n428 dataoutbuffer[0][1]
+ AOI22X1TS
XU1596 n1066 FE_DBTN132_n418 dataIn_WEST[1] n396 dataIn_EAST[1] AOI22X1TS
XU1598 n1065 FE_DBTN165_n2 dataIn_SOUTH[1] FE_DBTN162_n5 dataIn_NORTH[1]
+ AOI22X1TS
XU1601 n1073 FE_DBTN154_n14 cacheDataOut[2] FE_DBTN131_n428 dataoutbuffer[0][2]
+ AOI22X1TS
XU1602 n1072 FE_DBTN132_n418 dataIn_WEST[2] n396 dataIn_EAST[2] AOI22X1TS
XU1604 n1071 FE_DBTN165_n2 dataIn_SOUTH[2] FE_DBTN162_n5 dataIn_NORTH[2]
+ AOI22X1TS
XU1606 n1077 FE_DBTN154_n14 cacheDataOut[3] FE_DBTN131_n428 dataoutbuffer[0][3]
+ AOI22X1TS
XU1607 n1076 FE_DBTN132_n418 dataIn_WEST[3] n396 dataIn_EAST[3] AOI22X1TS
XU1609 n1075 FE_DBTN165_n2 dataIn_SOUTH[3] FE_DBTN162_n5 dataIn_NORTH[3]
+ AOI22X1TS
XU1611 n1084 FE_DBTN154_n14 cacheDataOut[4] FE_DBTN131_n428 dataoutbuffer[0][4]
+ AOI22X1TS
XU1612 n1083 FE_DBTN132_n418 dataIn_WEST[4] n396 dataIn_EAST[4] AOI22X1TS
XU1614 n1082 FE_DBTN165_n2 dataIn_SOUTH[4] FE_DBTN162_n5 dataIn_NORTH[4]
+ AOI22X1TS
XU1616 n1089 FE_DBTN154_n14 cacheDataOut[5] FE_DBTN131_n428 dataoutbuffer[0][5]
+ AOI22X1TS
XU1617 n1088 FE_DBTN132_n418 dataIn_WEST[5] n396 dataIn_EAST[5] AOI22X1TS
XU1619 n1087 FE_DBTN165_n2 dataIn_SOUTH[5] FE_DBTN162_n5 dataIn_NORTH[5]
+ AOI22X1TS
XU1621 n1096 n320 cacheDataOut[0] FE_DBTN135_n359 dataoutbuffer[1][0] AOI22X1TS
XU1622 n1095 FE_DBTN136_n346 dataIn_WEST[0] n318 dataIn_EAST[0] AOI22X1TS
XU1626 n1094 n333 dataIn_NORTH[0] n326 dataIn_SOUTH[0] AOI22X1TS
XU1628 n1103 n320 cacheDataOut[1] FE_DBTN135_n359 dataoutbuffer[1][1] AOI22X1TS
XU1629 n1102 FE_DBTN136_n346 dataIn_WEST[1] n318 dataIn_EAST[1] AOI22X1TS
XU1634 n1101 n333 dataIn_NORTH[1] n326 dataIn_SOUTH[1] AOI22X1TS
XU1637 n1110 n320 cacheDataOut[2] FE_DBTN135_n359 dataoutbuffer[1][2] AOI22X1TS
XU1638 n1109 FE_DBTN136_n346 dataIn_WEST[2] n318 dataIn_EAST[2] AOI22X1TS
XU1642 n1108 n333 dataIn_NORTH[2] n326 dataIn_SOUTH[2] AOI22X1TS
XU1644 n1339 n320 cacheDataOut[3] FE_DBTN135_n359 dataoutbuffer[1][3] AOI22X1TS
XU1645 n1338 FE_DBTN136_n346 dataIn_WEST[3] n318 dataIn_EAST[3] AOI22X1TS
XU1649 n1337 n333 dataIn_NORTH[3] n326 dataIn_SOUTH[3] AOI22X1TS
XU1650 n1345 n320 cacheDataOut[4] FE_DBTN135_n359 dataoutbuffer[1][4] AOI22X1TS
XU1651 n1344 FE_DBTN136_n346 dataIn_WEST[4] n318 dataIn_EAST[4] AOI22X1TS
XU1655 n1343 n333 dataIn_NORTH[4] n326 dataIn_SOUTH[4] AOI22X1TS
XU1656 n1351 n320 cacheDataOut[5] FE_DBTN135_n359 dataoutbuffer[1][5] AOI22X1TS
XU1657 n1350 FE_DBTN136_n346 dataIn_WEST[5] n318 dataIn_EAST[5] AOI22X1TS
XU1661 n1349 n333 dataIn_NORTH[5] n326 dataIn_SOUTH[5] AOI22X1TS
XU1663 n1356 FE_DBTN155_n13 cacheDataOut[0] FE_DBTN144_n1362
+ dataoutbuffer[2][0] AOI22X1TS
XU1664 n1355 FE_DBTN145_n202 dataIn_WEST[0] n185 dataIn_EAST[0] AOI22X1TS
XU1665 n1354 FE_DBTN163_n4 dataIn_NORTH[0] n192 dataIn_SOUTH[0] AOI22X1TS
XU1666 n1361 FE_DBTN155_n13 cacheDataOut[1] FE_DBTN144_n1362
+ dataoutbuffer[2][1] AOI22X1TS
XU1667 n1360 FE_DBTN145_n202 dataIn_WEST[1] n185 dataIn_EAST[1] AOI22X1TS
XU1668 n1359 FE_DBTN163_n4 dataIn_NORTH[1] n192 dataIn_SOUTH[1] AOI22X1TS
XU1670 n1368 FE_DBTN155_n13 cacheDataOut[2] FE_DBTN144_n1362
+ dataoutbuffer[2][2] AOI22X1TS
XU1671 n1367 FE_DBTN145_n202 dataIn_WEST[2] n185 dataIn_EAST[2] AOI22X1TS
XU1672 n1366 FE_DBTN163_n4 dataIn_NORTH[2] n192 dataIn_SOUTH[2] AOI22X1TS
XU1673 n1372 FE_DBTN155_n13 cacheDataOut[3] FE_DBTN144_n1362
+ dataoutbuffer[2][3] AOI22X1TS
XU1674 n1371 FE_DBTN145_n202 dataIn_WEST[3] n185 dataIn_EAST[3] AOI22X1TS
XU1675 n1370 FE_DBTN163_n4 dataIn_NORTH[3] n192 dataIn_SOUTH[3] AOI22X1TS
XU1676 n1379 FE_DBTN155_n13 cacheDataOut[4] FE_DBTN144_n1362
+ dataoutbuffer[2][4] AOI22X1TS
XU1677 n1378 FE_DBTN145_n202 dataIn_WEST[4] n185 dataIn_EAST[4] AOI22X1TS
XU1678 n1377 FE_DBTN163_n4 dataIn_NORTH[4] n192 dataIn_SOUTH[4] AOI22X1TS
XU1679 n1386 FE_DBTN155_n13 cacheDataOut[5] FE_DBTN144_n1362
+ dataoutbuffer[2][5] AOI22X1TS
XU1680 n1385 FE_DBTN145_n202 dataIn_WEST[5] n185 dataIn_EAST[5] AOI22X1TS
XU1681 n1384 FE_DBTN163_n4 dataIn_NORTH[5] n192 dataIn_SOUTH[5] AOI22X1TS
XU1683 n1391 n131 cacheDataOut[0] FE_DBTN147_n1397 dataoutbuffer[3][0]
+ AOI22X1TS
XU1684 n1390 n135 dataIn_WEST[0] n139 dataIn_EAST[0] AOI22X1TS
XU1685 n1389 n140 dataIn_NORTH[0] n130 dataIn_SOUTH[0] AOI22X1TS
XU1686 n1396 n131 cacheDataOut[1] FE_DBTN147_n1397 dataoutbuffer[3][1]
+ AOI22X1TS
XU1687 n1395 n135 dataIn_WEST[1] n139 dataIn_EAST[1] AOI22X1TS
XU1689 n1394 n140 dataIn_NORTH[1] n130 dataIn_SOUTH[1] AOI22X1TS
XU1691 n1401 n131 cacheDataOut[2] FE_DBTN147_n1397 dataoutbuffer[3][2]
+ AOI22X1TS
XU1692 n1400 n135 dataIn_WEST[2] n139 dataIn_EAST[2] AOI22X1TS
XU1693 n1399 n140 dataIn_NORTH[2] n130 dataIn_SOUTH[2] AOI22X1TS
XU1694 n1405 n131 cacheDataOut[3] FE_DBTN147_n1397 dataoutbuffer[3][3]
+ AOI22X1TS
XU1695 n1404 n135 dataIn_WEST[3] n139 dataIn_EAST[3] AOI22X1TS
XU1696 n1403 n140 dataIn_NORTH[3] n130 dataIn_SOUTH[3] AOI22X1TS
XU1698 n1410 n131 cacheDataOut[4] FE_DBTN147_n1397 dataoutbuffer[3][4]
+ AOI22X1TS
XU1699 n1409 n135 dataIn_WEST[4] n139 dataIn_EAST[4] AOI22X1TS
XU1700 n1408 n140 dataIn_NORTH[4] n130 dataIn_SOUTH[4] AOI22X1TS
XU1702 n1417 n131 cacheDataOut[5] FE_DBTN147_n1397 dataoutbuffer[3][5]
+ AOI22X1TS
XU1703 n1416 n135 dataIn_WEST[5] n139 dataIn_EAST[5] AOI22X1TS
XU1704 n1415 n140 dataIn_NORTH[5] n130 dataIn_SOUTH[5] AOI22X1TS
XU1706 n1422 FE_DBTN156_n12 cacheDataOut[0] FE_DBTN138_n1429
+ dataoutbuffer[4][0] AOI22X1TS
XU1708 n1421 FE_DBTN139_n293 dataIn_WEST[0] n278 dataIn_EAST[0] AOI22X1TS
XU1709 n1420 FE_DBTN166_n1 dataIn_SOUTH[0] FE_DBTN161_n6 dataIn_NORTH[0]
+ AOI22X1TS
XU1710 n1428 FE_DBTN156_n12 cacheDataOut[1] FE_DBTN138_n1429
+ dataoutbuffer[4][1] AOI22X1TS
XU1712 n1427 FE_DBTN139_n293 dataIn_WEST[1] n278 dataIn_EAST[1] AOI22X1TS
XU1713 n1426 FE_DBTN166_n1 dataIn_SOUTH[1] FE_DBTN161_n6 dataIn_NORTH[1]
+ AOI22X1TS
XU1715 n1435 FE_DBTN156_n12 cacheDataOut[2] FE_DBTN138_n1429
+ dataoutbuffer[4][2] AOI22X1TS
XU1717 n1434 FE_DBTN139_n293 dataIn_WEST[2] n278 dataIn_EAST[2] AOI22X1TS
XU1718 n1433 FE_DBTN166_n1 dataIn_SOUTH[2] FE_DBTN161_n6 dataIn_NORTH[2]
+ AOI22X1TS
XU1719 n1439 FE_DBTN156_n12 cacheDataOut[3] FE_DBTN138_n1429
+ dataoutbuffer[4][3] AOI22X1TS
XU1721 n1438 FE_DBTN139_n293 dataIn_WEST[3] n278 dataIn_EAST[3] AOI22X1TS
XU1722 n1437 FE_DBTN166_n1 dataIn_SOUTH[3] FE_DBTN161_n6 dataIn_NORTH[3]
+ AOI22X1TS
XU1723 n1445 FE_DBTN156_n12 cacheDataOut[4] FE_DBTN138_n1429
+ dataoutbuffer[4][4] AOI22X1TS
XU1725 n1444 FE_DBTN139_n293 dataIn_WEST[4] n278 dataIn_EAST[4] AOI22X1TS
XU1726 n1443 FE_DBTN166_n1 dataIn_SOUTH[4] FE_DBTN161_n6 dataIn_NORTH[4]
+ AOI22X1TS
XU1727 n1450 FE_DBTN156_n12 cacheDataOut[5] FE_DBTN138_n1429
+ dataoutbuffer[4][5] AOI22X1TS
XU1729 n1449 FE_DBTN139_n293 dataIn_WEST[5] n278 dataIn_EAST[5] AOI22X1TS
XU1730 n1448 FE_DBTN166_n1 dataIn_SOUTH[5] FE_DBTN161_n6 dataIn_NORTH[5]
+ AOI22X1TS
XU1732 n1454 FE_DBTN157_n11 cacheDataOut[0] FE_DBTN141_n1460
+ dataoutbuffer[5][0] AOI22X1TS
XU1733 n1453 FE_DBTN143_n243 dataIn_WEST[0] n225 dataIn_EAST[0] AOI22X1TS
XU1734 n1452 n230 dataIn_NORTH[0] FE_DBTN142_n250 dataIn_SOUTH[0] AOI22X1TS
XU1735 n1459 FE_DBTN157_n11 cacheDataOut[1] FE_DBTN141_n1460
+ dataoutbuffer[5][1] AOI22X1TS
XU1736 n1458 FE_DBTN143_n243 dataIn_WEST[1] n225 dataIn_EAST[1] AOI22X1TS
XU1737 n1457 n230 dataIn_NORTH[1] FE_DBTN142_n250 dataIn_SOUTH[1] AOI22X1TS
XU1739 n1465 FE_DBTN157_n11 cacheDataOut[2] FE_DBTN141_n1460
+ dataoutbuffer[5][2] AOI22X1TS
XU1740 n1464 FE_DBTN143_n243 dataIn_WEST[2] n225 dataIn_EAST[2] AOI22X1TS
XU1741 n1463 n230 dataIn_NORTH[2] FE_DBTN142_n250 dataIn_SOUTH[2] AOI22X1TS
XU1742 n1470 FE_DBTN157_n11 cacheDataOut[3] FE_DBTN141_n1460
+ dataoutbuffer[5][3] AOI22X1TS
XU1743 n1469 FE_DBTN143_n243 dataIn_WEST[3] n225 dataIn_EAST[3] AOI22X1TS
XU1744 n1468 n230 dataIn_NORTH[3] FE_DBTN142_n250 dataIn_SOUTH[3] AOI22X1TS
XU1745 n1475 FE_DBTN157_n11 cacheDataOut[4] FE_DBTN141_n1460
+ dataoutbuffer[5][4] AOI22X1TS
XU1746 n1474 FE_DBTN143_n243 dataIn_WEST[4] n225 dataIn_EAST[4] AOI22X1TS
XU1747 n1473 n230 dataIn_NORTH[4] FE_DBTN142_n250 dataIn_SOUTH[4] AOI22X1TS
XU1748 n1479 FE_DBTN157_n11 cacheDataOut[5] FE_DBTN141_n1460
+ dataoutbuffer[5][5] AOI22X1TS
XU1749 n1478 FE_DBTN143_n243 dataIn_WEST[5] n225 dataIn_EAST[5] AOI22X1TS
XU1750 n1477 n230 dataIn_NORTH[5] FE_DBTN142_n250 dataIn_SOUTH[5] AOI22X1TS
XU1752 n1486 FE_DBTN158_n10 cacheDataOut[0] FE_DBTN148_n1496
+ dataoutbuffer[6][0] AOI22X1TS
XU1753 n1485 FE_DBTN149_n106 dataIn_WEST[0] n85 dataIn_EAST[0] AOI22X1TS
XU1754 n1484 FE_DBTN160_n7 dataIn_NORTH[0] n92 dataIn_SOUTH[0] AOI22X1TS
XU1755 n1495 FE_DBTN158_n10 cacheDataOut[1] FE_DBTN148_n1496
+ dataoutbuffer[6][1] AOI22X1TS
XU1756 n1494 FE_DBTN149_n106 dataIn_WEST[1] n85 dataIn_EAST[1] AOI22X1TS
XU1757 n1493 FE_DBTN160_n7 dataIn_NORTH[1] n92 dataIn_SOUTH[1] AOI22X1TS
XU1759 n1506 FE_DBTN158_n10 cacheDataOut[2] FE_DBTN148_n1496
+ dataoutbuffer[6][2] AOI22X1TS
XU1760 n1505 FE_DBTN149_n106 dataIn_WEST[2] n85 dataIn_EAST[2] AOI22X1TS
XU1761 n1504 FE_DBTN160_n7 dataIn_NORTH[2] n92 dataIn_SOUTH[2] AOI22X1TS
XU1762 n1514 FE_DBTN158_n10 cacheDataOut[3] FE_DBTN148_n1496
+ dataoutbuffer[6][3] AOI22X1TS
XU1763 n1513 FE_DBTN149_n106 dataIn_WEST[3] n85 dataIn_EAST[3] AOI22X1TS
XU1764 n1512 FE_DBTN160_n7 dataIn_NORTH[3] n92 dataIn_SOUTH[3] AOI22X1TS
XU1765 n1521 FE_DBTN158_n10 cacheDataOut[4] FE_DBTN148_n1496
+ dataoutbuffer[6][4] AOI22X1TS
XU1766 n1520 FE_DBTN149_n106 dataIn_WEST[4] n85 dataIn_EAST[4] AOI22X1TS
XU1767 n1519 FE_DBTN160_n7 dataIn_NORTH[4] n92 dataIn_SOUTH[4] AOI22X1TS
XU1768 n1529 FE_DBTN158_n10 cacheDataOut[5] FE_DBTN148_n1496
+ dataoutbuffer[6][5] AOI22X1TS
XU1769 n1528 FE_DBTN149_n106 dataIn_WEST[5] n85 dataIn_EAST[5] AOI22X1TS
XU1770 n1527 FE_DBTN160_n7 dataIn_NORTH[5] n92 dataIn_SOUTH[5] AOI22X1TS
XU1771 n1537 n36 cacheDataOut[0] FE_DBTN152_n1547 dataoutbuffer[7][0] AOI22X1TS
XU1772 n1536 FE_DBTN153_n57 dataIn_WEST[0] n34 dataIn_EAST[0] AOI22X1TS
XU1773 n1535 FE_DBTN164_n3 dataIn_SOUTH[0] FE_DBTN151_n62 dataIn_NORTH[0]
+ AOI22X1TS
XU1774 n1546 n36 cacheDataOut[1] FE_DBTN152_n1547 dataoutbuffer[7][1] AOI22X1TS
XU1775 n1545 FE_DBTN153_n57 dataIn_WEST[1] n34 dataIn_EAST[1] AOI22X1TS
XU1776 n1544 FE_DBTN164_n3 dataIn_SOUTH[1] FE_DBTN151_n62 dataIn_NORTH[1]
+ AOI22X1TS
XU1778 n1555 n36 cacheDataOut[2] FE_DBTN152_n1547 dataoutbuffer[7][2] AOI22X1TS
XU1779 n1554 FE_DBTN153_n57 dataIn_WEST[2] n34 dataIn_EAST[2] AOI22X1TS
XU1781 n1553 FE_DBTN164_n3 dataIn_SOUTH[2] FE_DBTN151_n62 dataIn_NORTH[2]
+ AOI22X1TS
XU1782 n1563 n36 cacheDataOut[3] FE_DBTN152_n1547 dataoutbuffer[7][3] AOI22X1TS
XU1783 n1562 FE_DBTN153_n57 dataIn_WEST[3] n34 dataIn_EAST[3] AOI22X1TS
XU1784 n1561 FE_DBTN164_n3 dataIn_SOUTH[3] FE_DBTN151_n62 dataIn_NORTH[3]
+ AOI22X1TS
XU1785 n1571 n36 cacheDataOut[4] FE_DBTN152_n1547 dataoutbuffer[7][4] AOI22X1TS
XU1786 n1570 FE_DBTN153_n57 dataIn_WEST[4] n34 dataIn_EAST[4] AOI22X1TS
XU1787 n1569 FE_DBTN164_n3 dataIn_SOUTH[4] FE_DBTN151_n62 dataIn_NORTH[4]
+ AOI22X1TS
XU1788 n1581 n36 cacheDataOut[5] FE_DBTN152_n1547 dataoutbuffer[7][5] AOI22X1TS
XU1789 n1580 FE_DBTN153_n57 dataIn_WEST[5] n34 dataIn_EAST[5] AOI22X1TS
XU1790 n1579 FE_DBTN164_n3 dataIn_SOUTH[5] FE_DBTN151_n62 dataIn_NORTH[5]
+ AOI22X1TS
XU1792 n1586 n1584 readIn_SOUTH readIn_NORTH n1583 AOI22X1TS
XU1793 n1589 n1587 FE_DBTN217_readInBuffer_EAST n1586 n1585 AOI22X1TS
XU1794 n1593 n1590 readIn_WEST n1589 n1588 AOI22X1TS
XU1795 n1217 n1593 n1547 n1591 FE_DBTN152_n1547 n1964 AOI32X1TS
XU1797 n1597 n1595 readIn_SOUTH readIn_NORTH n1594 AOI22X1TS
XU1798 n1600 n1598 FE_DBTN217_readInBuffer_EAST n1597 n1596 AOI22X1TS
XU1799 n1604 n1601 readIn_WEST n1600 n1599 AOI22X1TS
XU1800 n1216 n1604 n1496 n1602 FE_DBTN148_n1496 n1965 AOI32X1TS
XU1801 n1610 n1608 readIn_SOUTH readIn_NORTH n1605 AOI22X1TS
XU1802 n1613 n1611 FE_DBTN217_readInBuffer_EAST n1610 n1609 AOI22X1TS
XU1803 n1617 n1614 readIn_WEST n1613 n1612 AOI22X1TS
XU1804 n1215 n1617 n1460 n1615 FE_DBTN141_n1460 n1966 AOI32X1TS
XU1807 n1621 n1619 readIn_SOUTH readIn_NORTH n1618 AOI22X1TS
XU1808 n1624 n1622 FE_DBTN217_readInBuffer_EAST n1621 n1620 AOI22X1TS
XU1809 n1629 n1626 readIn_WEST n1624 n1623 AOI22X1TS
XU1810 n1214 n1629 n1429 n1627 FE_DBTN138_n1429 n1967 AOI32X1TS
XU1811 n1631 n122 readIn_SOUTH readIn_NORTH n28 AOI22X1TS
XU1812 n1634 n1632 FE_DBTN217_readInBuffer_EAST n1631 n1630 AOI22X1TS
XU1813 n1638 n1635 readIn_WEST n1634 n1633 AOI22X1TS
XU1814 n1213 n1638 n1397 n1636 FE_DBTN147_n1397 n1968 AOI32X1TS
XU1815 n1642 n1640 readIn_SOUTH readIn_NORTH n1639 AOI22X1TS
XU1816 n1646 n1644 FE_DBTN217_readInBuffer_EAST n1642 n1641 AOI22X1TS
XU1817 n1650 n1647 readIn_WEST n1646 n1645 AOI22X1TS
XU1818 n1212 n1650 n1362 n1648 FE_DBTN144_n1362 n1969 AOI32X1TS
XU1819 n1656 n1654 readIn_SOUTH readIn_NORTH n1651 AOI22X1TS
XU1820 n1659 n1657 FE_DBTN217_readInBuffer_EAST n1656 n1655 AOI22X1TS
XU1821 n1663 n1661 readIn_WEST n1659 n1658 AOI22X1TS
XU1822 n1211 n1663 n359 n1662 FE_DBTN135_n359 n1970 AOI32X1TS
XU1823 n1668 n1666 readIn_SOUTH readIn_NORTH n1664 AOI22X1TS
XU1824 n1672 n1670 FE_DBTN217_readInBuffer_EAST n1668 n1667 AOI22X1TS
XU1825 n1675 n1673 readIn_WEST n1672 n1671 AOI22X1TS
XU1826 n1210 n1675 n428 n1674 FE_DBTN131_n428 n1971 AOI32X1TS
XU1827 n1680 readRequesterAddress[0] n36 FE_DBTN152_n1547
+ destinationAddressbuffer[7][0] AOI22X1TS
XU1829 n1679 FE_DBTN153_n57 destinationAddressIn_WEST[0] n34
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1831 n1678 FE_DBTN164_n3 destinationAddressIn_SOUTH[0] FE_DBTN151_n62
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1832 n1688 n36 readRequesterAddress[1] FE_DBTN152_n1547
+ destinationAddressbuffer[7][1] AOI22X1TS
XU1834 n1687 FE_DBTN153_n57 destinationAddressIn_WEST[1] n34
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1836 n1686 FE_DBTN164_n3 destinationAddressIn_SOUTH[1] FE_DBTN151_n62
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1837 n1697 n36 readRequesterAddress[2] FE_DBTN152_n1547
+ destinationAddressbuffer[7][2] AOI22X1TS
XU1839 n1696 FE_DBTN153_n57 destinationAddressIn_WEST[2] n34
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1841 n1695 FE_DBTN164_n3 destinationAddressIn_SOUTH[2] FE_DBTN151_n62
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1842 n1704 n36 readRequesterAddress[3] FE_DBTN152_n1547
+ destinationAddressbuffer[7][3] AOI22X1TS
XU1844 n1703 FE_DBTN153_n57 destinationAddressIn_WEST[3] n34
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1846 n1702 FE_DBTN164_n3 destinationAddressIn_SOUTH[3] FE_DBTN151_n62
+ destinationAddressIn_NORTH[3] AOI22X1TS
XU1847 n1709 readRequesterAddress[0] FE_DBTN158_n10 FE_DBTN148_n1496
+ destinationAddressbuffer[6][0] AOI22X1TS
XU1848 n1708 FE_DBTN149_n106 destinationAddressIn_WEST[0] n85
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1852 n1707 FE_DBTN160_n7 destinationAddressIn_NORTH[0] n92
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1853 n1717 readRequesterAddress[1] FE_DBTN158_n10 FE_DBTN148_n1496
+ destinationAddressbuffer[6][1] AOI22X1TS
XU1854 n1716 FE_DBTN149_n106 destinationAddressIn_WEST[1] n85
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1858 n1715 FE_DBTN160_n7 destinationAddressIn_NORTH[1] n92
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1859 n1727 readRequesterAddress[2] FE_DBTN158_n10 FE_DBTN148_n1496
+ destinationAddressbuffer[6][2] AOI22X1TS
XU1860 n1726 FE_DBTN149_n106 destinationAddressIn_WEST[2] n85
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1864 n1725 FE_DBTN160_n7 destinationAddressIn_NORTH[2] n92
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1865 n1733 readRequesterAddress[3] FE_DBTN158_n10 FE_DBTN148_n1496
+ destinationAddressbuffer[6][3] AOI22X1TS
XU1866 n1732 FE_DBTN149_n106 destinationAddressIn_WEST[3] n85
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1870 n1731 FE_DBTN160_n7 destinationAddressIn_NORTH[3] n92
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1871 n1737 readRequesterAddress[0] FE_DBTN157_n11 FE_DBTN141_n1460
+ destinationAddressbuffer[5][0] AOI22X1TS
XU1872 n1736 FE_DBTN143_n243 destinationAddressIn_WEST[0] n225
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1873 n1735 n230 destinationAddressIn_NORTH[0] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1874 n1746 readRequesterAddress[1] FE_DBTN157_n11 FE_DBTN141_n1460
+ destinationAddressbuffer[5][1] AOI22X1TS
XU1875 n1745 FE_DBTN143_n243 destinationAddressIn_WEST[1] n225
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1876 n1744 n230 destinationAddressIn_NORTH[1] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1877 n1754 readRequesterAddress[2] FE_DBTN157_n11 FE_DBTN141_n1460
+ destinationAddressbuffer[5][2] AOI22X1TS
XU1878 n1753 FE_DBTN143_n243 destinationAddressIn_WEST[2] n225
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1879 n1752 n230 destinationAddressIn_NORTH[2] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1880 n1761 readRequesterAddress[3] FE_DBTN157_n11 FE_DBTN141_n1460
+ destinationAddressbuffer[5][3] AOI22X1TS
XU1881 n1760 FE_DBTN143_n243 destinationAddressIn_WEST[3] n225
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1882 n1759 n230 destinationAddressIn_NORTH[3] FE_DBTN142_n250
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1883 n1766 readRequesterAddress[0] FE_DBTN156_n12 FE_DBTN138_n1429
+ destinationAddressbuffer[4][0] AOI22X1TS
XU1884 n1765 FE_DBTN139_n293 destinationAddressIn_WEST[0] n278
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1885 n1764 FE_DBTN166_n1 destinationAddressIn_SOUTH[0] FE_DBTN161_n6
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1886 n1775 readRequesterAddress[1] FE_DBTN156_n12 FE_DBTN138_n1429
+ destinationAddressbuffer[4][1] AOI22X1TS
XU1887 n1774 FE_DBTN139_n293 destinationAddressIn_WEST[1] n278
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1888 n1773 FE_DBTN166_n1 destinationAddressIn_SOUTH[1] FE_DBTN161_n6
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1889 n1786 readRequesterAddress[2] FE_DBTN156_n12 FE_DBTN138_n1429
+ destinationAddressbuffer[4][2] AOI22X1TS
XU1890 n1785 FE_DBTN139_n293 destinationAddressIn_WEST[2] n278
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1891 n1784 FE_DBTN166_n1 destinationAddressIn_SOUTH[2] FE_DBTN161_n6
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1892 n1794 readRequesterAddress[3] FE_DBTN156_n12 FE_DBTN138_n1429
+ destinationAddressbuffer[4][3] AOI22X1TS
XU1893 n1793 FE_DBTN139_n293 destinationAddressIn_WEST[3] n278
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1894 n1792 FE_DBTN166_n1 destinationAddressIn_SOUTH[3] FE_DBTN161_n6
+ destinationAddressIn_NORTH[3] AOI22X1TS
XU1895 n1799 readRequesterAddress[0] n131 FE_DBTN147_n1397
+ destinationAddressbuffer[3][0] AOI22X1TS
XU1896 n1798 n135 destinationAddressIn_WEST[0] n139
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1897 n1797 n140 destinationAddressIn_NORTH[0] n130
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1898 n1807 readRequesterAddress[1] n131 FE_DBTN147_n1397
+ destinationAddressbuffer[3][1] AOI22X1TS
XU1899 n1806 n135 destinationAddressIn_WEST[1] n139
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1900 n1805 n140 destinationAddressIn_NORTH[1] n130
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1901 n1814 readRequesterAddress[2] n131 FE_DBTN147_n1397
+ destinationAddressbuffer[3][2] AOI22X1TS
XU1902 n1813 n135 destinationAddressIn_WEST[2] n139
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1903 n1812 n140 destinationAddressIn_NORTH[2] n130
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1904 n1824 readRequesterAddress[3] n131 FE_DBTN147_n1397
+ destinationAddressbuffer[3][3] AOI22X1TS
XU1905 n1823 n135 destinationAddressIn_WEST[3] n139
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1906 n1822 n140 destinationAddressIn_NORTH[3] n130
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1907 n1828 readRequesterAddress[0] FE_DBTN155_n13 FE_DBTN144_n1362
+ destinationAddressbuffer[2][0] AOI22X1TS
XU1908 n1827 FE_DBTN145_n202 destinationAddressIn_WEST[0] n185
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1909 n1826 FE_DBTN163_n4 destinationAddressIn_NORTH[0] n192
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1910 n1835 readRequesterAddress[1] FE_DBTN155_n13 FE_DBTN144_n1362
+ destinationAddressbuffer[2][1] AOI22X1TS
XU1911 n1834 FE_DBTN145_n202 destinationAddressIn_WEST[1] n185
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1912 n1833 FE_DBTN163_n4 destinationAddressIn_NORTH[1] n192
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1913 n1844 readRequesterAddress[2] FE_DBTN155_n13 FE_DBTN144_n1362
+ destinationAddressbuffer[2][2] AOI22X1TS
XU1914 n1843 FE_DBTN145_n202 destinationAddressIn_WEST[2] n185
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1915 n1842 FE_DBTN163_n4 destinationAddressIn_NORTH[2] n192
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1916 n1850 readRequesterAddress[3] FE_DBTN155_n13 FE_DBTN144_n1362
+ destinationAddressbuffer[2][3] AOI22X1TS
XU1917 n1849 FE_DBTN145_n202 destinationAddressIn_WEST[3] n185
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1918 n1848 FE_DBTN163_n4 destinationAddressIn_NORTH[3] n192
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1919 n1857 readRequesterAddress[0] n320 FE_DBTN135_n359
+ destinationAddressbuffer[1][0] AOI22X1TS
XU1920 n1856 FE_DBTN136_n346 destinationAddressIn_WEST[0] n318
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1921 n1855 n333 destinationAddressIn_NORTH[0] n326
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1922 n1868 readRequesterAddress[1] n320 FE_DBTN135_n359
+ destinationAddressbuffer[1][1] AOI22X1TS
XU1923 n1867 FE_DBTN136_n346 destinationAddressIn_WEST[1] n318
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1924 n1866 n333 destinationAddressIn_NORTH[1] n326
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1925 n1880 readRequesterAddress[2] n320 FE_DBTN135_n359
+ destinationAddressbuffer[1][2] AOI22X1TS
XU1926 n1879 FE_DBTN136_n346 destinationAddressIn_WEST[2] n318
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1927 n1878 n333 destinationAddressIn_NORTH[2] n326
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1928 n1891 readRequesterAddress[3] n320 FE_DBTN135_n359
+ destinationAddressbuffer[1][3] AOI22X1TS
XU1929 n1890 FE_DBTN136_n346 destinationAddressIn_WEST[3] n318
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1930 n1889 n333 destinationAddressIn_NORTH[3] n326
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1931 n1899 readRequesterAddress[0] FE_DBTN154_n14 FE_DBTN131_n428
+ destinationAddressbuffer[0][0] AOI22X1TS
XU1932 n1898 FE_DBTN132_n418 destinationAddressIn_WEST[0] n396
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1933 n1897 FE_DBTN165_n2 destinationAddressIn_SOUTH[0] FE_DBTN162_n5
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1934 n1910 readRequesterAddress[1] FE_DBTN154_n14 FE_DBTN131_n428
+ destinationAddressbuffer[0][1] AOI22X1TS
XU1935 n1909 FE_DBTN132_n418 destinationAddressIn_WEST[1] n396
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1936 n1908 FE_DBTN165_n2 destinationAddressIn_SOUTH[1] FE_DBTN162_n5
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1937 n1922 readRequesterAddress[2] FE_DBTN154_n14 FE_DBTN131_n428
+ destinationAddressbuffer[0][2] AOI22X1TS
XU1938 n1921 FE_DBTN132_n418 destinationAddressIn_WEST[2] n396
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1939 n1920 FE_DBTN165_n2 destinationAddressIn_SOUTH[2] FE_DBTN162_n5
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1940 n1933 readRequesterAddress[3] FE_DBTN154_n14 FE_DBTN131_n428
+ destinationAddressbuffer[0][3] AOI22X1TS
XU1941 n1932 FE_DBTN132_n418 destinationAddressIn_WEST[3] n396
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1942 n1931 FE_DBTN165_n2 destinationAddressIn_SOUTH[3] FE_DBTN162_n5
+ destinationAddressIn_NORTH[3] AOI22X1TS
.ENDS

.SUBCKT outputPortArbiter_1 clk reset selectBit_NORTH
+ destinationAddressIn_NORTH[11] destinationAddressIn_NORTH[10]
+ destinationAddressIn_NORTH[9] destinationAddressIn_NORTH[8]
+ destinationAddressIn_NORTH[7] destinationAddressIn_NORTH[6]
+ destinationAddressIn_NORTH[5] destinationAddressIn_NORTH[4]
+ destinationAddressIn_NORTH[3] destinationAddressIn_NORTH[2]
+ destinationAddressIn_NORTH[1] destinationAddressIn_NORTH[0]
+ requesterAddressIn_NORTH[3] requesterAddressIn_NORTH[2]
+ requesterAddressIn_NORTH[1] requesterAddressIn_NORTH[0] readIn_NORTH
+ writeIn_NORTH dataIn_NORTH[5] dataIn_NORTH[4] dataIn_NORTH[3] dataIn_NORTH[2]
+ dataIn_NORTH[1] dataIn_NORTH[0] selectBit_SOUTH
+ destinationAddressIn_SOUTH[11] destinationAddressIn_SOUTH[10]
+ destinationAddressIn_SOUTH[9] destinationAddressIn_SOUTH[8]
+ destinationAddressIn_SOUTH[7] destinationAddressIn_SOUTH[6]
+ destinationAddressIn_SOUTH[5] destinationAddressIn_SOUTH[4]
+ destinationAddressIn_SOUTH[3] destinationAddressIn_SOUTH[2]
+ destinationAddressIn_SOUTH[1] destinationAddressIn_SOUTH[0]
+ requesterAddressIn_SOUTH[3] requesterAddressIn_SOUTH[2]
+ requesterAddressIn_SOUTH[1] requesterAddressIn_SOUTH[0] readIn_SOUTH
+ writeIn_SOUTH dataIn_SOUTH[5] dataIn_SOUTH[4] dataIn_SOUTH[3] dataIn_SOUTH[2]
+ dataIn_SOUTH[1] dataIn_SOUTH[0] selectBit_EAST destinationAddressIn_EAST[11]
+ destinationAddressIn_EAST[10] destinationAddressIn_EAST[9]
+ destinationAddressIn_EAST[8] destinationAddressIn_EAST[7]
+ destinationAddressIn_EAST[6] destinationAddressIn_EAST[5]
+ destinationAddressIn_EAST[4] destinationAddressIn_EAST[3]
+ destinationAddressIn_EAST[2] destinationAddressIn_EAST[1]
+ destinationAddressIn_EAST[0] requesterAddressIn_EAST[3]
+ requesterAddressIn_EAST[2] requesterAddressIn_EAST[1]
+ requesterAddressIn_EAST[0] readIn_EAST writeIn_EAST dataIn_EAST[5]
+ dataIn_EAST[4] dataIn_EAST[3] dataIn_EAST[2] dataIn_EAST[1] dataIn_EAST[0]
+ selectBit_WEST destinationAddressIn_WEST[11] destinationAddressIn_WEST[10]
+ destinationAddressIn_WEST[9] destinationAddressIn_WEST[8]
+ destinationAddressIn_WEST[7] destinationAddressIn_WEST[6]
+ destinationAddressIn_WEST[5] destinationAddressIn_WEST[4]
+ destinationAddressIn_WEST[3] destinationAddressIn_WEST[2]
+ destinationAddressIn_WEST[1] destinationAddressIn_WEST[0]
+ requesterAddressIn_WEST[3] requesterAddressIn_WEST[2]
+ requesterAddressIn_WEST[1] requesterAddressIn_WEST[0] readIn_WEST
+ writeIn_WEST dataIn_WEST[5] dataIn_WEST[4] dataIn_WEST[3] dataIn_WEST[2]
+ dataIn_WEST[1] dataIn_WEST[0] readReady readRequesterAddress[3]
+ readRequesterAddress[2] readRequesterAddress[1] readRequesterAddress[0]
+ cacheDataOut[5] cacheDataOut[4] cacheDataOut[3] cacheDataOut[2]
+ cacheDataOut[1] cacheDataOut[0] destinationAddressOut[11]
+ destinationAddressOut[10] destinationAddressOut[9] destinationAddressOut[8]
+ destinationAddressOut[7] destinationAddressOut[6] destinationAddressOut[5]
+ destinationAddressOut[4] destinationAddressOut[3] destinationAddressOut[2]
+ destinationAddressOut[1] destinationAddressOut[0] requesterAddressOut[3]
+ requesterAddressOut[2] requesterAddressOut[1] requesterAddressOut[0] readOut
+ writeOut dataOut[5] dataOut[4] dataOut[3] dataOut[2] dataOut[1] dataOut[0]
XFE_DBTC216_readInBuffer_EAST FE_DBTN216_readInBuffer_EAST readIn_EAST INVX2TS
XFE_DBTC211_destinationAddressInBuffer_EAST_11_
+ FE_DBTN211_destinationAddressInBuffer_EAST_11_ destinationAddressIn_EAST[11]
+ INVX2TS
XFE_DBTC208_destinationAddressInBuffer_EAST_10_
+ FE_DBTN208_destinationAddressInBuffer_EAST_10_ destinationAddressIn_EAST[10]
+ INVX2TS
XFE_DBTC205_destinationAddressInBuffer_EAST_9_
+ FE_DBTN205_destinationAddressInBuffer_EAST_9_ destinationAddressIn_EAST[9]
+ INVX2TS
XFE_DBTC202_destinationAddressInBuffer_EAST_8_
+ FE_DBTN202_destinationAddressInBuffer_EAST_8_ destinationAddressIn_EAST[8]
+ INVX2TS
XFE_DBTC198_destinationAddressInBuffer_EAST_7_
+ FE_DBTN198_destinationAddressInBuffer_EAST_7_ destinationAddressIn_EAST[7]
+ INVX2TS
XFE_DBTC195_destinationAddressInBuffer_EAST_6_
+ FE_DBTN195_destinationAddressInBuffer_EAST_6_ destinationAddressIn_EAST[6]
+ INVX2TS
XFE_DBTC192_destinationAddressInBuffer_EAST_5_
+ FE_DBTN192_destinationAddressInBuffer_EAST_5_ destinationAddressIn_EAST[5]
+ INVX2TS
XFE_DBTC189_destinationAddressInBuffer_EAST_4_
+ FE_DBTN189_destinationAddressInBuffer_EAST_4_ destinationAddressIn_EAST[4]
+ INVX2TS
XFE_DBTC40_n1 FE_DBTN40_n1 n1 INVX2TS
XFE_DBTC39_n2 FE_DBTN39_n2 n2 INVX2TS
XFE_DBTC38_n3 FE_DBTN38_n3 n3 INVX2TS
XFE_DBTC37_n4 FE_DBTN37_n4 n4 INVX2TS
XFE_DBTC36_n5 FE_DBTN36_n5 n5 INVX2TS
XFE_DBTC35_n6 FE_DBTN35_n6 n6 INVX2TS
XFE_DBTC34_n7 FE_DBTN34_n7 n7 INVX2TS
XFE_DBTC33_n9 FE_DBTN33_n9 n9 INVX2TS
XFE_DBTC32_n10 FE_DBTN32_n10 n10 INVX2TS
XFE_DBTC31_n11 FE_DBTN31_n11 n11 INVX2TS
XFE_DBTC30_n12 FE_DBTN30_n12 n12 INVX2TS
XFE_DBTC29_n13 FE_DBTN29_n13 n13 INVX2TS
XFE_DBTC28_n52 FE_DBTN28_n52 n52 INVX2TS
XFE_DBTC27_n1536 FE_DBTN27_n1536 n1536 INVX2TS
XFE_DBTC26_n66 FE_DBTN26_n66 n66 INVX2TS
XFE_DBTC25_n1954 FE_DBTN25_n1954 n1954 INVX2TS
XFE_DBTC24_n100 FE_DBTN24_n100 n100 INVX2TS
XFE_DBTC23_n1484 FE_DBTN23_n1484 n1484 INVX2TS
XFE_DBTC22_n1390 FE_DBTN22_n1390 n1390 INVX2TS
XFE_DBTC21_n198 FE_DBTN21_n198 n198 INVX2TS
XFE_DBTC20_n1356 FE_DBTN20_n1356 n1356 INVX2TS
XFE_DBTC19_n221 FE_DBTN19_n221 n221 INVX2TS
XFE_DBTC18_n241 FE_DBTN18_n241 n241 INVX2TS
XFE_DBTC17_n253 FE_DBTN17_n253 n253 INVX2TS
XFE_DBTC16_n1450 FE_DBTN16_n1450 n1450 INVX2TS
XFE_DBTC15_n1952 FE_DBTN15_n1952 n1952 INVX2TS
XFE_DBTC14_n289 FE_DBTN14_n289 n289 INVX2TS
XFE_DBTC13_n1419 FE_DBTN13_n1419 n1419 INVX2TS
XFE_DBTC12_n1950 FE_DBTN12_n1950 n1950 INVX2TS
XFE_DBTC11_n343 FE_DBTN11_n343 n343 INVX2TS
XFE_DBTC10_n356 FE_DBTN10_n356 n356 INVX2TS
XFE_DBTC9_n1949 FE_DBTN9_n1949 n1949 INVX2TS
XFE_DBTC8_n1946 FE_DBTN8_n1946 n1946 INVX2TS
XFE_DBTC7_n415 FE_DBTN7_n415 n415 INVX2TS
XFE_DBTC6_n425 FE_DBTN6_n425 n425 INVX2TS
XFE_DBTC5_n1951 FE_DBTN5_n1951 n1951 INVX2TS
XFE_DBTC4_n676 FE_DBTN4_n676 n676 INVX2TS
XFE_DBTC3_n1953 FE_DBTN3_n1953 n1953 INVX2TS
XFE_DBTC2_n1945 FE_DBTN2_n1945 n1945 INVX2TS
XFE_DBTC1_n1944 FE_DBTN1_n1944 n1944 INVX2TS
XFE_DBTC0_n562 FE_DBTN0_n562 n562 INVX2TS
Xfull_reg_reg 1000 n1955 clk N2624 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][0] requesterAddressbuffer[2][0] 1001 clk n2015
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][1] requesterAddressbuffer[2][1] 1002 clk n2016
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][2] requesterAddressbuffer[2][2] 1003 clk n2017
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][3] requesterAddressbuffer[2][3] 1004 clk n2018
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][0] destinationAddressbuffer[2][0] 1005 clk
+ n2151 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][1] destinationAddressbuffer[2][1] 1006 clk
+ n2152 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][2] destinationAddressbuffer[2][2] 1007 clk
+ n2153 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][3] destinationAddressbuffer[2][3] 1008 clk
+ n2154 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][0] dataoutbuffer[0][0] 1009 clk n2027 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][1] dataoutbuffer[0][1] 1010 clk n2028 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][2] dataoutbuffer[0][2] 1011 clk n2029 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][3] dataoutbuffer[0][3] 1012 clk n2030 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][4] dataoutbuffer[0][4] 1013 clk n2031 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][5] dataoutbuffer[0][5] 1014 clk n2032 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[7] writeOutbuffer[7] 1015 clk n2075 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][4] destinationAddressbuffer[7][4] 1016 clk
+ n2095 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][5] destinationAddressbuffer[7][5] 1017 clk
+ n2096 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][6] destinationAddressbuffer[7][6] 1018 clk
+ n2097 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][7] destinationAddressbuffer[7][7] 1019 clk
+ n2098 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][8] destinationAddressbuffer[7][8] 1020 clk
+ n2099 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][9] destinationAddressbuffer[7][9] 1021 clk
+ n2100 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][11] destinationAddressbuffer[7][11] 1022 clk
+ n2102 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[6] writeOutbuffer[6] 1023 clk n2076 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][4] destinationAddressbuffer[6][4] 1024 clk
+ n2107 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][5] destinationAddressbuffer[6][5] 1025 clk
+ n2108 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][6] destinationAddressbuffer[6][6] 1026 clk
+ n2109 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][7] destinationAddressbuffer[6][7] 1027 clk
+ n2110 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][8] destinationAddressbuffer[6][8] 1028 clk
+ n2111 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][9] destinationAddressbuffer[6][9] 1029 clk
+ n2112 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][10] destinationAddressbuffer[6][10] 1030 clk
+ n2113 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][11] destinationAddressbuffer[6][11] 1031 clk
+ n2114 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[3] writeOutbuffer[3] 1032 clk n2079 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][4] destinationAddressbuffer[3][4] 1033 clk
+ n2143 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][5] destinationAddressbuffer[3][5] 1034 clk
+ n2144 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][6] destinationAddressbuffer[3][6] 1035 clk
+ n2145 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][7] destinationAddressbuffer[3][7] 1036 clk
+ n2146 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][8] destinationAddressbuffer[3][8] 1037 clk
+ n2147 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][9] destinationAddressbuffer[3][9] 1038 clk
+ n2148 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][10] destinationAddressbuffer[3][10] 1039 clk
+ n2149 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][11] destinationAddressbuffer[3][11] 1040 clk
+ n2150 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[2] writeOutbuffer[2] 1041 clk n2080 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][4] destinationAddressbuffer[2][4] 1042 clk
+ n2155 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][5] destinationAddressbuffer[2][5] 1043 clk
+ n2156 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][6] destinationAddressbuffer[2][6] 1044 clk
+ n2157 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][7] destinationAddressbuffer[2][7] 1045 clk
+ n2158 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][8] destinationAddressbuffer[2][8] 1046 clk
+ n2159 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][9] destinationAddressbuffer[2][9] 1047 clk
+ n2160 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][10] destinationAddressbuffer[2][10] 1048 clk
+ n2161 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][11] destinationAddressbuffer[2][11] 1049 clk
+ n2162 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][0] dataoutbuffer[7][0] 1050 clk n2069 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][1] dataoutbuffer[7][1] 1051 clk n2070 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][2] dataoutbuffer[7][2] 1052 clk n2071 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][3] dataoutbuffer[7][3] 1053 clk n2072 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][4] dataoutbuffer[7][4] 1054 clk n2073 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][5] dataoutbuffer[7][5] 1055 clk n2074 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][0] dataoutbuffer[6][0] 1056 clk n2063 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][1] dataoutbuffer[6][1] 1057 clk n2064 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][2] dataoutbuffer[6][2] 1058 clk n2065 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][3] dataoutbuffer[6][3] 1059 clk n2066 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][4] dataoutbuffer[6][4] 1060 clk n2067 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][5] dataoutbuffer[6][5] 1061 clk n2068 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][0] requesterAddressbuffer[5][0] 1062 clk n2003
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][1] requesterAddressbuffer[5][1] 1063 clk n2004
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][2] requesterAddressbuffer[5][2] 1064 clk n2005
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][3] requesterAddressbuffer[5][3] 1065 clk n2006
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][0] destinationAddressbuffer[5][0] 1066 clk
+ n2115 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][1] destinationAddressbuffer[5][1] 1067 clk
+ n2116 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][2] destinationAddressbuffer[5][2] 1068 clk
+ n2117 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][3] destinationAddressbuffer[5][3] 1069 clk
+ n2118 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][0] requesterAddressbuffer[4][0] 1070 clk n2007
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][1] requesterAddressbuffer[4][1] 1071 clk n2008
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][2] requesterAddressbuffer[4][2] 1072 clk n2009
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][3] requesterAddressbuffer[4][3] 1073 clk n2010
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][0] destinationAddressbuffer[4][0] 1074 clk
+ n2127 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][1] destinationAddressbuffer[4][1] 1075 clk
+ n2128 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][2] destinationAddressbuffer[4][2] 1076 clk
+ n2129 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][3] destinationAddressbuffer[4][3] 1077 clk
+ n2130 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][0] dataoutbuffer[3][0] 1078 clk n2045 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][1] dataoutbuffer[3][1] 1079 clk n2046 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][2] dataoutbuffer[3][2] 1080 clk n2047 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][3] dataoutbuffer[3][3] 1081 clk n2048 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][4] dataoutbuffer[3][4] 1082 clk n2049 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][5] dataoutbuffer[3][5] 1083 clk n2050 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][0] dataoutbuffer[2][0] 1084 clk n2039 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][1] dataoutbuffer[2][1] 1085 clk n2040 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][2] dataoutbuffer[2][2] 1086 clk n2041 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][3] dataoutbuffer[2][3] 1087 clk n2042 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][4] dataoutbuffer[2][4] 1088 clk n2043 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][5] dataoutbuffer[2][5] 1089 clk n2044 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][0] requesterAddressbuffer[1][0] 1090 clk n2019
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][1] requesterAddressbuffer[1][1] 1091 clk n2020
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][2] requesterAddressbuffer[1][2] 1092 clk n2021
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][3] requesterAddressbuffer[1][3] 1093 clk n2022
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][0] destinationAddressbuffer[1][0] 1094 clk
+ n2163 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][1] destinationAddressbuffer[1][1] 1095 clk
+ n2164 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][2] destinationAddressbuffer[1][2] 1096 clk
+ n2165 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][3] destinationAddressbuffer[1][3] 1097 clk
+ n2166 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][0] requesterAddressbuffer[0][0] 1098 clk n2023
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][1] requesterAddressbuffer[0][1] 1099 clk n2024
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][2] requesterAddressbuffer[0][2] 1100 clk n2025
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][3] requesterAddressbuffer[0][3] 1101 clk n2026
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][0] destinationAddressbuffer[0][0] 1102 clk
+ n2175 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][1] destinationAddressbuffer[0][1] 1103 clk
+ n2176 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][2] destinationAddressbuffer[0][2] 1104 clk
+ n2177 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][3] destinationAddressbuffer[0][3] 1105 clk
+ n2178 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][0] requesterAddressbuffer[7][0] 1106 clk n1995
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][1] requesterAddressbuffer[7][1] 1107 clk n1996
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][2] requesterAddressbuffer[7][2] 1108 clk n1997
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][3] requesterAddressbuffer[7][3] 1109 clk n1998
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][0] destinationAddressbuffer[7][0] 1110 clk
+ n2091 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][1] destinationAddressbuffer[7][1] 1111 clk
+ n2092 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][2] destinationAddressbuffer[7][2] 1112 clk
+ n2093 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][3] destinationAddressbuffer[7][3] 1113 clk
+ n2094 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][0] requesterAddressbuffer[6][0] 1114 clk n1999
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][1] requesterAddressbuffer[6][1] 1115 clk n2000
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][2] requesterAddressbuffer[6][2] 1116 clk n2001
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][3] requesterAddressbuffer[6][3] 1117 clk n2002
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][0] destinationAddressbuffer[6][0] 1118 clk
+ n2103 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][1] destinationAddressbuffer[6][1] 1119 clk
+ n2104 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][2] destinationAddressbuffer[6][2] 1120 clk
+ n2105 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][3] destinationAddressbuffer[6][3] 1121 clk
+ n2106 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][0] dataoutbuffer[5][0] 1122 clk n2057 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][1] dataoutbuffer[5][1] 1123 clk n2058 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][2] dataoutbuffer[5][2] 1124 clk n2059 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][3] dataoutbuffer[5][3] 1125 clk n2060 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][4] dataoutbuffer[5][4] 1126 clk n2061 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][5] dataoutbuffer[5][5] 1127 clk n2062 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][0] dataoutbuffer[4][0] 1128 clk n2051 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][1] dataoutbuffer[4][1] 1129 clk n2052 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][2] dataoutbuffer[4][2] 1130 clk n2053 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][3] dataoutbuffer[4][3] 1131 clk n2054 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][4] dataoutbuffer[4][4] 1132 clk n2055 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][5] dataoutbuffer[4][5] 1133 clk n2056 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][0] requesterAddressbuffer[3][0] 1134 clk n2011
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][1] requesterAddressbuffer[3][1] 1135 clk n2012
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][2] requesterAddressbuffer[3][2] 1136 clk n2013
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][3] requesterAddressbuffer[3][3] 1137 clk n2014
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][0] destinationAddressbuffer[3][0] 1138 clk
+ n2139 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][1] destinationAddressbuffer[3][1] 1139 clk
+ n2140 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][2] destinationAddressbuffer[3][2] 1140 clk
+ n2141 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][3] destinationAddressbuffer[3][3] 1141 clk
+ n2142 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][0] dataoutbuffer[1][0] 1142 clk n2033 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][1] dataoutbuffer[1][1] 1143 clk n2034 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][2] dataoutbuffer[1][2] 1144 clk n2035 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][3] dataoutbuffer[1][3] 1145 clk n2036 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][4] dataoutbuffer[1][4] 1146 clk n2037 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][5] dataoutbuffer[1][5] 1147 clk n2038 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[5] writeOutbuffer[5] 1148 clk n2077 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][4] destinationAddressbuffer[5][4] 1149 clk
+ n2119 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][5] destinationAddressbuffer[5][5] 1150 clk
+ n2120 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][6] destinationAddressbuffer[5][6] 1151 clk
+ n2121 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][7] destinationAddressbuffer[5][7] 1152 clk
+ n2122 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][8] destinationAddressbuffer[5][8] 1153 clk
+ n2123 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][9] destinationAddressbuffer[5][9] 1154 clk
+ n2124 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][10] destinationAddressbuffer[5][10] 1155 clk
+ n2125 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][11] destinationAddressbuffer[5][11] 1156 clk
+ n2126 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[4] writeOutbuffer[4] 1157 clk n2078 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][4] destinationAddressbuffer[4][4] 1158 clk
+ n2131 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][5] destinationAddressbuffer[4][5] 1159 clk
+ n2132 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][6] destinationAddressbuffer[4][6] 1160 clk
+ n2133 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][7] destinationAddressbuffer[4][7] 1161 clk
+ n2134 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][8] destinationAddressbuffer[4][8] 1162 clk
+ n2135 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][9] destinationAddressbuffer[4][9] 1163 clk
+ n2136 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][10] destinationAddressbuffer[4][10] 1164 clk
+ n2137 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][11] destinationAddressbuffer[4][11] 1165 clk
+ n2138 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[1] writeOutbuffer[1] 1166 clk n2081 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][4] destinationAddressbuffer[1][4] 1167 clk
+ n2167 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][5] destinationAddressbuffer[1][5] 1168 clk
+ n2168 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][6] destinationAddressbuffer[1][6] 1169 clk
+ n2169 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][7] destinationAddressbuffer[1][7] 1170 clk
+ n2170 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][8] destinationAddressbuffer[1][8] 1171 clk
+ n2171 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][9] destinationAddressbuffer[1][9] 1172 clk
+ n2172 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][10] destinationAddressbuffer[1][10] 1173 clk
+ n2173 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][11] destinationAddressbuffer[1][11] 1174 clk
+ n2174 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[0] writeOutbuffer[0] 1175 clk n2082 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][4] destinationAddressbuffer[0][4] 1176 clk
+ n2179 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][5] destinationAddressbuffer[0][5] 1177 clk
+ n2180 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][6] destinationAddressbuffer[0][6] 1178 clk
+ n2181 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][7] destinationAddressbuffer[0][7] 1179 clk
+ n2182 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][8] destinationAddressbuffer[0][8] 1180 clk
+ n2183 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][9] destinationAddressbuffer[0][9] 1181 clk
+ n2184 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][10] destinationAddressbuffer[0][10] 1182 clk
+ n2185 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][11] destinationAddressbuffer[0][11] 1183 clk
+ n2186 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][10] destinationAddressbuffer[7][10] 1184 clk
+ n2101 VDD VDD DFFNSRX1TS
XwriteOut_reg writeOut 1185 clk n1972 VDD VDD DFFNSRX1TS
XdestinationAddressOut_reg[4] destinationAddressOut[4] 1186 clk n1981 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[5] destinationAddressOut[5] 1187 clk n1982 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[6] destinationAddressOut[6] 1188 clk n1983 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[7] destinationAddressOut[7] 1189 clk n1984 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[8] destinationAddressOut[8] 1190 clk n1985 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[9] destinationAddressOut[9] 1191 clk n1986 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[10] destinationAddressOut[10] 1192 clk n1987 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[11] destinationAddressOut[11] 1193 clk n1988 VDD VDD
+ DFFNSRX1TS
XreadOut_reg readOut 1194 clk n1971 VDD VDD DFFNSRX1TS
XrequesterAddressOut_reg[0] requesterAddressOut[0] 1195 clk n1973 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[1] requesterAddressOut[1] 1196 clk n1974 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[2] requesterAddressOut[2] 1197 clk n1975 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[3] requesterAddressOut[3] 1198 clk n1976 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[0] destinationAddressOut[0] 1199 clk n1977 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[1] destinationAddressOut[1] 1200 clk n1978 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[2] destinationAddressOut[2] 1201 clk n1979 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[3] destinationAddressOut[3] 1202 clk n1980 VDD VDD
+ DFFNSRX1TS
XdataOut_reg[0] dataOut[0] 1203 clk n1989 VDD VDD DFFNSRX1TS
XdataOut_reg[1] dataOut[1] 1204 clk n1990 VDD VDD DFFNSRX1TS
XdataOut_reg[2] dataOut[2] 1205 clk n1991 VDD VDD DFFNSRX1TS
XdataOut_reg[3] dataOut[3] 1206 clk n1992 VDD VDD DFFNSRX1TS
XdataOut_reg[4] dataOut[4] 1207 clk n1993 VDD VDD DFFNSRX1TS
XdataOut_reg[5] dataOut[5] 1208 clk n1994 VDD VDD DFFNSRX1TS
Xread_reg_reg[1] n1948 n1947 clk n1970 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[0] n1946 n1950 clk n1965 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[2] n1951 n1952 clk n1967 VDD VDD DFFNSRX1TS
Xread_reg_reg[0] n1941 n1953 clk n1964 VDD VDD DFFNSRX1TS
Xread_reg_reg[2] n1944 n1945 clk n1969 VDD VDD DFFNSRX1TS
Xempty_reg_reg n1943 n1942 clk n1968 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[7] readOutbuffer[7] n1956 clk n2083 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[4] readOutbuffer[4] n1959 clk n2086 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[6] readOutbuffer[6] n1957 clk n2084 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[5] readOutbuffer[5] n1958 clk n2085 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[0] readOutbuffer[0] n1963 clk n2090 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[2] readOutbuffer[2] n1961 clk n2088 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[1] readOutbuffer[1] n1962 clk n2089 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[3] readOutbuffer[3] n1960 clk n2087 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[1] n1949 n1954 clk n1966 VDD VDD DFFNSRX1TS
XU3 n481 n496 n488 FE_DBTN25_n1954 n486 CMPR32X2TS
XU5 n466 n461 selectBit_SOUTH selectBit_NORTH selectBit_EAST CMPR32X2TS
XU7 n509 selectBit_WEST selectBit_EAST readReady NOR3XLTS
XU8 n191 n1629 n187 NOR2XLTS
XU9 n1621 n127 n385 NOR2XLTS
XU10 n1609 n1611 INVX2TS
XU11 n1598 n1600 INVX2TS
XU12 n1585 n1587 INVX2TS
XU13 n1574 n1576 INVX2TS
XU14 n1634 n1636 INVX2TS
XU15 n1603 n15 n79 n267 NOR3XLTS
XU17 n540 selectBit_NORTH selectBit_SOUTH NOR2XLTS
XU18 n324 n1640 n323 NOR2XLTS
XU19 n137 n1622 n136 NOR2XLTS
XU20 n317 FE_DBTN19_n221 n1651 NOR2XLTS
XU21 n133 FE_DBTN19_n221 n1625 NOR2XLTS
XU22 n274 FE_DBTN19_n221 n1616 NOR2XLTS
XU23 n223 n1603 n1598 n227 NOR3XLTS
XU24 n86 FE_DBTN19_n221 n1591 NOR2XLTS
XU25 n91 n1583 n90 NOR2XLTS
XU26 n35 n1580 FE_DBTN19_n221 NOR2XLTS
XU27 n132 n27 n135 NOR2XLTS
XU28 n490 n492 FE_DBTN2_n1945 n489 OAI21XLTS
XU29 n494 reset INVX2TS
XU30 n493 n492 FE_DBTN2_n1945 n491 n490 AOI211XLTS
XU31 n54 n1572 n40 NOR2X1TS
XU32 n1357 n183 INVX2TS
XU33 n147 n123 n135 NOR2X1TS
XU34 n187 n186 n185 NAND2BXLTS
XU35 n135 n136 n131 NAND2BXLTS
XU36 n90 n89 n88 NAND2BXLTS
XU37 n400 n399 n398 NAND2BXLTS
XU38 n278 n277 n276 NAND2BXLTS
XU39 n323 n322 n321 NAND2BXLTS
XU40 n1576 n127 n269 NOR2X1TS
XU41 n385 n126 selectBit_EAST NAND2BX1TS
XU42 n491 FE_DBTN3_n1953 n495 XOR2XLTS
XU43 n1594 n25 n220 FE_DBTN34_n7 NAND3X1TS
XU44 n1572 FE_DBTN25_n1954 n25 n220 NAND3X1TS
XU45 n310 n220 FE_DBTN34_n7 NOR2X1TS
XU46 n29 n8 FE_DBTN34_n7 NOR2X1TS
XU47 n383 n125 selectBit_WEST NAND2BX1TS
XU48 n221 n525 n1955 AND2X2TS
XU49 n465 n478 selectBit_WEST readReady n461 ADDFX1TS
XU51 n18 n15 n466 FE_DBTN25_n1954 n17 ADDFX1TS
XU52 n19 FE_DBTN8_n1946 n506 NOR2X1TS
XU54 n1 n1663 n1657 n399 OR3X1TS
XU56 n1600 n311 n310 n269 NOR3X1TS
XU57 n226 n1603 n1600 NOR2XLTS
XU58 n539 readReady selectBit_WEST selectBit_EAST NOR3BXLTS
XU59 n136 n134 n1625 NAND2X1TS
XU60 n1419 n275 n274 OR2X1TS
XU61 n1450 n224 FE_DBTN30_n12 OR2X1TS
XU62 n1356 n184 FE_DBTN32_n10 OR2X1TS
XU63 n1390 n134 n133 OR2X1TS
XU64 n1484 n87 n86 OR2X1TS
XU65 n1536 n36 n35 OR2X1TS
XU66 n486 n480 n479 CLKAND2X2TS
XU67 n1625 FE_DBTN25_n1954 n1946 readReady FE_DBTN5_n1951 NAND4XLTS
XU68 n1622 n1624 INVX2TS
XU70 n1651 FE_DBTN12_n1950 readReady FE_DBTN5_n1951 FE_DBTN9_n1949 NAND4XLTS
XU71 n1650 n15 n79 n383 NOR3XLTS
XU72 n1644 n1646 INVX2TS
XU73 n1636 n16 n181 n383 NOR3XLTS
XU74 n1630 n1633 INVX2TS
XU76 n1663 n15 n16 n383 NOR3XLTS
XU77 n1657 n1660 INVX2TS
XU79 n1591 FE_DBTN25_n1954 FE_DBTN15_n1952 readReady FE_DBTN8_n1946 NAND4XLTS
XU80 n1590 n16 n181 n267 NOR3XLTS
XU81 n1583 n1584 INVX2TS
XU83 n1616 FE_DBTN15_n1952 readReady FE_DBTN8_n1946 FE_DBTN9_n1949 NAND4XLTS
XU84 n1615 n15 n16 n267 NOR3XLTS
XU86 n1580 FE_DBTN12_n1950 FE_DBTN25_n1954 FE_DBTN15_n1952 readReady NAND4XLTS
XU88 n562 n540 n1943 n539 NAND3XLTS
XU89 n553 n525 FE_DBTN4_n676 CLKAND2X2TS
XU90 n506 selectBit_NORTH INVX2TS
XU91 n276 n1615 n1611 NOR2XLTS
XU92 n38 n1579 n1576 NOR2XLTS
XU93 n185 n1636 n1633 NOR2XLTS
XU94 n455 n469 n532 FE_DBTN9_n1949 n463 ADDFX1TS
XU95 n398 n1663 n1660 NOR2XLTS
XU96 n22 FE_DBTN8_n1946 n506 n19 AO21X1TS
XU97 n126 n29 n24 n27 OAI21XLTS
XU98 n520 selectBit_NORTH n509 n508 NAND3XLTS
XU99 n519 selectBit_SOUTH n509 n506 NAND3XLTS
XU100 n321 n1650 n1646 NOR2XLTS
XU101 n131 n1624 n1621 NOR2XLTS
XU102 n228 n227 n226 NAND2BXLTS
XU103 n222 n19 FE_DBTN15_n1952 FE_DBTN9_n1949 NAND3XLTS
XU104 n88 n1590 n1587 NOR2XLTS
XU105 n40 n39 n38 NAND2BXLTS
XU106 n475 n455 n457 XOR2XLTS
XU107 n459 FE_DBTN25_n1954 n1947 n457 OAI21XLTS
XU109 n125 FE_DBTN15_n1952 n18 XOR2X1TS
XU110 n500 n221 reset NOR2XLTS
XU111 n1624 n181 n79 n383 NOR3X1TS
XU112 n1619 n1621 INVX2TS
XU113 n1643 n25 n7 n8 NOR3XLTS
XU114 n1640 n1643 INVX2TS
XU115 n1647 n1650 INVX2TS
XU116 n1646 n311 n310 n385 NOR3XLTS
XU117 n1637 FE_DBTN25_n1954 readReady FE_DBTN8_n1946 FE_DBTN5_n1951 NAND4XLTS
XU118 n1629 n25 n21 FE_DBTN34_n7 NOR3XLTS
XU119 n1628 n1629 INVX2TS
XU120 n1664 readReady FE_DBTN8_n1946 FE_DBTN9_n1949 FE_DBTN5_n1951 NAND4XLTS
XU121 n1656 n25 n7 n21 NOR3XLTS
XU122 n1661 n1663 INVX2TS
XU123 n1653 n1656 INVX2TS
XU124 n1660 n386 n385 n268 NOR3BXLTS
XU125 n1604 FE_DBTN12_n1950 FE_DBTN15_n1952 readReady FE_DBTN9_n1949 NAND4XLTS
XU126 n1601 n1603 INVX2TS
XU127 n1588 n1590 INVX2TS
XU128 n1608 n7 n21 n24 NOR3XLTS
XU129 n1607 n1608 INVX2TS
XU130 n1612 n1615 INVX2TS
XU131 n1611 n386 n269 n268 NOR3BXLTS
XU132 n1577 n15 n16 n125 selectBit_WEST NAND4XLTS
XU133 n1573 n1572 INVX2TS
XU134 n144 destinationAddressIn_SOUTH[11] INVX2TS
XU135 n140 destinationAddressIn_SOUTH[10] INVX2TS
XU136 n150 destinationAddressIn_SOUTH[9] INVX2TS
XU137 n154 destinationAddressIn_SOUTH[8] INVX2TS
XU138 n485 n480 n478 CLKAND2X2TS
XU139 n1967 n1951 n500 n499 n498 AO22XLTS
XU140 n1965 n1946 n500 n499 n495 AO22XLTS
XU141 n1966 FE_DBTN25_n1954 n500 n499 n496 AO22XLTS
XU142 n1968 n221 n452 n494 OAI21XLTS
XU143 n1994 n875 n874 n873 n872 NAND4XLTS
XU144 n1993 n851 n850 n849 n848 NAND4XLTS
XU145 n1992 n839 n838 n837 n836 NAND4XLTS
XU146 n1991 n827 n826 n825 n824 NAND4XLTS
XU147 n1990 n808 n807 n806 n805 NAND4XLTS
XU148 n1989 n788 n787 n786 n785 NAND4XLTS
XU149 n1980 n658 n657 n656 n655 NAND4XLTS
XU150 n1979 n646 n645 n644 n643 NAND4XLTS
XU151 n1978 n627 n626 n625 n624 NAND4XLTS
XU152 n1977 n612 n611 n610 n609 NAND4XLTS
XU153 n1976 n601 n600 n599 n655 NAND4XLTS
XU154 n1975 n590 n589 n588 n643 NAND4XLTS
XU155 n1974 n582 n581 n580 n624 NAND4XLTS
XU156 n1973 n565 n564 n563 n609 NAND4XLTS
XU157 n1971 n543 n542 n541 n562 NAND4XLTS
XU158 n1988 n778 n777 n776 NAND3XLTS
XU159 n1987 n764 n763 n762 NAND3XLTS
XU160 n1986 n749 n748 n747 NAND3XLTS
XU161 n1985 n731 n730 n729 NAND3XLTS
XU162 n1984 n717 n716 n715 NAND3XLTS
XU163 n1983 n706 n705 n704 NAND3XLTS
XU164 n1982 n691 n690 n689 NAND3XLTS
XU165 n1981 n669 n668 n667 NAND3XLTS
XU166 n1972 n556 n555 n554 NAND3XLTS
XU167 n2038 n1345 n1344 n1343 NAND3XLTS
XU168 n2037 n1339 n1338 n1337 NAND3XLTS
XU169 n2036 n1110 n1109 n1108 NAND3XLTS
XU170 n2035 n1104 n1103 n1102 NAND3XLTS
XU171 n2034 n1095 n1094 n1093 NAND3XLTS
XU172 n2033 n1088 n1087 n1086 NAND3XLTS
XU173 n2142 n1816 n1815 n1814 NAND3XLTS
XU174 n2141 n1806 n1805 n1804 NAND3XLTS
XU175 n2140 n1801 n1800 n1799 NAND3XLTS
XU176 n2139 n1794 n1793 n1792 NAND3XLTS
XU177 n2014 n985 n984 n983 NAND3XLTS
XU178 n2013 n979 n978 n977 NAND3XLTS
XU179 n2012 n971 n970 n969 NAND3XLTS
XU180 n2011 n963 n962 n961 NAND3XLTS
XU181 n2056 n1440 n1439 n1438 NAND3XLTS
XU182 n2055 n1434 n1433 n1432 NAND3XLTS
XU183 n2054 n1430 n1429 n1428 NAND3XLTS
XU184 n2053 n1426 n1425 n1424 NAND3XLTS
XU185 n2052 n1417 n1416 n1415 NAND3XLTS
XU186 n2051 n1412 n1411 n1410 NAND3XLTS
XU187 n2062 n1466 n1465 n1464 NAND3XLTS
XU188 n2061 n1461 n1460 n1459 NAND3XLTS
XU189 n2060 n1458 n1457 n1456 NAND3XLTS
XU190 n2059 n1454 n1453 n1452 NAND3XLTS
XU191 n2058 n1449 n1448 n1447 NAND3XLTS
XU192 n2057 n1444 n1443 n1442 NAND3XLTS
XU193 n2106 n1723 n1722 n1721 NAND3XLTS
XU194 n2105 n1716 n1715 n1714 NAND3XLTS
XU195 n2104 n1708 n1707 n1706 NAND3XLTS
XU196 n2103 n1699 n1698 n1697 NAND3XLTS
XU197 n2002 n910 n909 n908 NAND3XLTS
XU198 n2001 n904 n903 n902 NAND3XLTS
XU199 n2000 n901 n900 n899 NAND3XLTS
XU200 n1999 n896 n895 n894 NAND3XLTS
XU201 n2094 n1694 n1693 n1692 NAND3XLTS
XU202 n2093 n1687 n1686 n1685 NAND3XLTS
XU203 n2092 n1678 n1677 n1676 NAND3XLTS
XU204 n2091 n1671 n1670 n1669 NAND3XLTS
XU205 n1998 n893 n892 n891 NAND3XLTS
XU206 n1997 n888 n887 n886 NAND3XLTS
XU207 n1996 n884 n883 n882 NAND3XLTS
XU208 n1995 n881 n880 n879 NAND3XLTS
XU209 n2178 n1925 n1924 n1923 NAND3XLTS
XU210 n2177 n1915 n1914 n1913 NAND3XLTS
XU211 n2176 n1904 n1903 n1902 NAND3XLTS
XU212 n2175 n1893 n1892 n1891 NAND3XLTS
XU213 n2026 n1058 n1057 n1056 NAND3XLTS
XU214 n2025 n1051 n1050 n1049 NAND3XLTS
XU215 n2024 n1046 n1045 n1044 NAND3XLTS
XU216 n2023 n1039 n1038 n1037 NAND3XLTS
XU217 n2166 n1886 n1885 n1884 NAND3XLTS
XU218 n2165 n1876 n1875 n1874 NAND3XLTS
XU219 n2164 n1863 n1862 n1861 NAND3XLTS
XU220 n2163 n1852 n1851 n1850 NAND3XLTS
XU221 n2022 n1033 n1032 n1031 NAND3XLTS
XU222 n2021 n1024 n1023 n1022 NAND3XLTS
XU223 n2020 n1016 n1015 n1014 NAND3XLTS
XU224 n2019 n1009 n1008 n1007 NAND3XLTS
XU225 n2044 n1378 n1377 n1376 NAND3XLTS
XU226 n2043 n1372 n1371 n1370 NAND3XLTS
XU227 n2042 n1368 n1367 n1366 NAND3XLTS
XU228 n2041 n1363 n1362 n1361 NAND3XLTS
XU229 n2040 n1355 n1354 n1353 NAND3XLTS
XU230 n2039 n1349 n1348 n1347 NAND3XLTS
XU231 n2050 n1407 n1406 n1405 NAND3XLTS
XU232 n2049 n1402 n1401 n1400 NAND3XLTS
XU233 n2048 n1397 n1396 n1395 NAND3XLTS
XU234 n2047 n1394 n1393 n1392 NAND3XLTS
XU235 n2046 n1388 n1387 n1386 NAND3XLTS
XU236 n2045 n1382 n1381 n1380 NAND3XLTS
XU237 n2130 n1787 n1786 n1785 NAND3XLTS
XU238 n2129 n1781 n1780 n1779 NAND3XLTS
XU239 n2128 n1771 n1770 n1769 NAND3XLTS
XU240 n2127 n1763 n1762 n1761 NAND3XLTS
XU241 n2010 n956 n955 n954 NAND3XLTS
XU242 n2009 n948 n947 n946 NAND3XLTS
XU243 n2008 n942 n941 n940 NAND3XLTS
XU244 n2007 n935 n934 n933 NAND3XLTS
XU245 n2118 n1758 n1757 n1756 NAND3XLTS
XU246 n2117 n1749 n1748 n1747 NAND3XLTS
XU247 n2116 n1738 n1737 n1736 NAND3XLTS
XU248 n2115 n1729 n1728 n1727 NAND3XLTS
XU249 n2006 n927 n926 n925 NAND3XLTS
XU250 n2005 n920 n919 n918 NAND3XLTS
XU251 n2004 n917 n916 n915 NAND3XLTS
XU252 n2003 n913 n912 n911 NAND3XLTS
XU253 n2068 n1518 n1517 n1516 NAND3XLTS
XU254 n2067 n1509 n1508 n1507 NAND3XLTS
XU255 n2066 n1502 n1501 n1500 NAND3XLTS
XU256 n2065 n1494 n1493 n1492 NAND3XLTS
XU257 n2064 n1482 n1481 n1480 NAND3XLTS
XU258 n2063 n1474 n1473 n1472 NAND3XLTS
XU259 n2074 n1570 n1569 n1568 NAND3XLTS
XU260 n2073 n1561 n1560 n1559 NAND3XLTS
XU261 n2072 n1551 n1550 n1549 NAND3XLTS
XU262 n2071 n1543 n1542 n1541 NAND3XLTS
XU263 n2070 n1535 n1534 n1533 NAND3XLTS
XU264 n2069 n1527 n1526 n1525 NAND3XLTS
XU265 n2032 n1083 n1082 n1081 NAND3XLTS
XU266 n2031 n1079 n1078 n1077 NAND3XLTS
XU267 n2030 n1076 n1075 n1074 NAND3XLTS
XU268 n2029 n1073 n1072 n1071 NAND3XLTS
XU269 n2028 n1068 n1067 n1066 NAND3XLTS
XU270 n2027 n1062 n1061 n1060 NAND3XLTS
XU271 n2154 n1843 n1842 n1841 NAND3XLTS
XU272 n2153 n1836 n1835 n1834 NAND3XLTS
XU273 n2152 n1828 n1827 n1826 NAND3XLTS
XU274 n2151 n1821 n1820 n1819 NAND3XLTS
XU275 n2018 n1002 n1001 n1000 NAND3XLTS
XU276 n2017 n997 n996 n995 NAND3XLTS
XU277 n2016 n993 n992 n991 NAND3XLTS
XU278 n2015 n988 n987 n986 NAND3XLTS
XU279 n356 n318 n317 OR2X1TS
XU280 n27 n29 n24 NAND2X1TS
XU281 n57 writeIn_EAST INVX2TS
XU282 n2 n1597 n228 OR2X1TS
XU283 n3 n1584 n90 OR2X1TS
XU284 n4 n1628 n187 OR2X1TS
XU285 n5 n1656 n400 OR2X1TS
XU286 n6 n1653 n400 OR2X1TS
XU287 n7 n19 FE_DBTN25_n1954 n23 OA21XLTS
XU288 n8 n22 n508 OR2X1TS
XU289 n9 n1607 n278 OR2X1TS
XU290 n10 FE_DBTN19_n221 n1637 OR2X1TS
XU291 n11 n1608 n278 OR2X1TS
XU292 n425 n396 FE_DBTN29_n13 OR2X1TS
XU293 n33 n1579 n1574 n39 NOR3XLTS
XU294 n84 n1590 n1585 n89 NOR3XLTS
XU295 n273 n1615 n1609 n277 NOR3XLTS
XU296 n183 n1636 n1630 n186 NOR3XLTS
XU297 n315 n1650 n1644 n322 NOR3XLTS
XU298 n12 FE_DBTN19_n221 n1604 OR2X1TS
XU299 n13 FE_DBTN19_n221 n1664 OR2X1TS
XU300 n693 n1942 n520 NOR2XLTS
XU301 n545 n1942 n519 NOR2XLTS
XU328 n17 n16 FE_DBTN12_n1950 n461 ADDHX1TS
XU329 n79 n16 INVX2TS
XU331 n456 selectBit_WEST INVX2TS
XU332 n1579 n1577 INVX2TS
XU336 n508 selectBit_SOUTH INVX2TS
XU337 n220 n8 INVX2TS
XU340 n23 n19 FE_DBTN25_n1954 NAND2X1TS
XU342 n21 selectBit_SOUTH n22 NAND2X1TS
XU343 n268 selectBit_SOUTH n22 n21 OAI21XLTS
XU344 n127 n310 n268 NAND2X1TS
XU346 n128 n23 INVX2TS
XU348 n24 FE_DBTN15_n1952 n23 n128 FE_DBTN5_n1951 AOI22X1TS
XU349 n25 n24 INVX2TS
XU351 n123 n27 INVX2TS
XU353 n269 selectBit_EAST n126 NAND2X1TS
XU354 n32 FE_DBTN15_n1952 n128 NAND2X1TS
XU360 n525 n540 n509 NAND2X1TS
XU364 n36 n38 n32 n1572 FE_DBTN19_n221 AOI31XLTS
XU366 n39 n36 n1580 NAND2X1TS
XU367 n890 n33 INVX2TS
XU376 n52 n1577 n39 OR2X1TS
XU382 n42 FE_DBTN27_n1536 destinationAddressbuffer[7][11] FE_DBTN28_n52
+ destinationAddressIn_WEST[11] AOI22X1TS
XU386 n66 n1573 n40 OR2X1TS
XU390 n41 n54 destinationAddressIn_SOUTH[11] FE_DBTN26_n66
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU391 n2102 n890 FE_DBTN211_destinationAddressInBuffer_EAST_11_ n42 n41
+ OAI211XLTS
XU396 n46 FE_DBTN27_n1536 destinationAddressbuffer[7][10] FE_DBTN28_n52
+ destinationAddressIn_WEST[10] AOI22X1TS
XU402 n45 n54 destinationAddressIn_SOUTH[10] FE_DBTN26_n66
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU403 n2101 n890 FE_DBTN208_destinationAddressInBuffer_EAST_10_ n46 n45
+ OAI211XLTS
XU409 n50 FE_DBTN27_n1536 destinationAddressbuffer[7][8] FE_DBTN28_n52
+ destinationAddressIn_WEST[8] AOI22X1TS
XU414 n49 n54 destinationAddressIn_SOUTH[8] FE_DBTN26_n66
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU415 n2099 n890 FE_DBTN202_destinationAddressInBuffer_EAST_8_ n50 n49
+ OAI211XLTS
XU420 n56 FE_DBTN27_n1536 destinationAddressbuffer[7][9] FE_DBTN28_n52
+ destinationAddressIn_WEST[9] AOI22X1TS
XU428 n55 n54 destinationAddressIn_SOUTH[9] FE_DBTN26_n66
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU429 n2100 n890 FE_DBTN205_destinationAddressInBuffer_EAST_9_ n56 n55
+ OAI211XLTS
XU431 n61 FE_DBTN27_n1536 writeOutbuffer[7] FE_DBTN28_n52 writeIn_WEST
+ AOI22X1TS
XU433 n158 writeIn_SOUTH INVX2TS
XU438 n60 n54 writeIn_SOUTH FE_DBTN26_n66 writeIn_NORTH AOI22X1TS
XU439 n2075 n890 n57 n61 n60 OAI211XLTS
XU442 n64 FE_DBTN27_n1536 destinationAddressbuffer[7][6] FE_DBTN28_n52
+ destinationAddressIn_WEST[6] AOI22X1TS
XU443 n169 destinationAddressIn_SOUTH[6] INVX2TS
XU445 n63 n54 destinationAddressIn_SOUTH[6] FE_DBTN26_n66
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU446 n2097 n890 FE_DBTN195_destinationAddressInBuffer_EAST_6_ n64 n63
+ OAI211XLTS
XU448 n68 FE_DBTN27_n1536 destinationAddressbuffer[7][4] FE_DBTN28_n52
+ destinationAddressIn_WEST[4] AOI22X1TS
XU449 n163 destinationAddressIn_SOUTH[4] INVX2TS
XU452 n67 n54 destinationAddressIn_SOUTH[4] FE_DBTN26_n66
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU453 n2095 n890 FE_DBTN189_destinationAddressInBuffer_EAST_4_ n68 n67
+ OAI211XLTS
XU455 n72 FE_DBTN27_n1536 destinationAddressbuffer[7][7] FE_DBTN28_n52
+ destinationAddressIn_WEST[7] AOI22X1TS
XU456 n179 destinationAddressIn_SOUTH[7] INVX2TS
XU458 n71 n54 destinationAddressIn_SOUTH[7] FE_DBTN26_n66
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU459 n2098 n890 FE_DBTN198_destinationAddressInBuffer_EAST_7_ n72 n71
+ OAI211XLTS
XU461 n77 FE_DBTN27_n1536 destinationAddressbuffer[7][5] FE_DBTN28_n52
+ destinationAddressIn_WEST[5] AOI22X1TS
XU462 n174 destinationAddressIn_SOUTH[5] INVX2TS
XU464 n76 n54 destinationAddressIn_SOUTH[5] FE_DBTN26_n66
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU465 n2096 n890 FE_DBTN192_destinationAddressInBuffer_EAST_5_ n77 n76
+ OAI211XLTS
XU466 n181 n15 INVX2TS
XU467 n267 n125 selectBit_WEST NAND2X1TS
XU468 n386 n220 FE_DBTN34_n7 n310 AOI21X1TS
XU469 n1587 n386 n269 n268 NOR3XLTS
XU471 n389 FE_DBTN12_n1950 n506 NOR2XLTS
XU473 n1584 n24 n21 FE_DBTN34_n7 NOR3XLTS
XU474 n82 FE_DBTN15_n1952 FE_DBTN25_n1954 n389 n1584 AOI31XLTS
XU475 n87 n88 n82 FE_DBTN19_n221 AOI21X1TS
XU478 n89 n87 n1591 NAND2X1TS
XU479 n1468 n84 INVX2TS
XU487 n100 n1588 n89 OR2X1TS
XU489 n93 FE_DBTN23_n1484 destinationAddressbuffer[6][8] FE_DBTN24_n100
+ destinationAddressIn_WEST[8] AOI22X1TS
XU495 n92 FE_DBTN38_n3 destinationAddressIn_NORTH[8] n91
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU496 n2111 n1468 FE_DBTN202_destinationAddressInBuffer_EAST_8_ n93 n92
+ OAI211XLTS
XU498 n95 FE_DBTN23_n1484 destinationAddressbuffer[6][9] FE_DBTN24_n100
+ destinationAddressIn_WEST[9] AOI22X1TS
XU502 n94 FE_DBTN38_n3 destinationAddressIn_NORTH[9] n91
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU503 n2112 n1468 FE_DBTN205_destinationAddressInBuffer_EAST_9_ n95 n94
+ OAI211XLTS
XU506 n99 FE_DBTN23_n1484 destinationAddressbuffer[6][10] FE_DBTN24_n100
+ destinationAddressIn_WEST[10] AOI22X1TS
XU513 n98 FE_DBTN38_n3 destinationAddressIn_NORTH[10] n91
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU514 n2113 n1468 FE_DBTN208_destinationAddressInBuffer_EAST_10_ n99 n98
+ OAI211XLTS
XU518 n107 FE_DBTN23_n1484 destinationAddressbuffer[6][11] FE_DBTN24_n100
+ destinationAddressIn_WEST[11] AOI22X1TS
XU524 n106 FE_DBTN38_n3 destinationAddressIn_NORTH[11] n91
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU525 n2114 n1468 FE_DBTN211_destinationAddressInBuffer_EAST_11_ n107 n106
+ OAI211XLTS
XU527 n109 FE_DBTN23_n1484 writeOutbuffer[6] FE_DBTN24_n100 writeIn_WEST
+ AOI22X1TS
XU531 n108 FE_DBTN38_n3 writeIn_NORTH n91 writeIn_SOUTH AOI22X1TS
XU532 n2076 n1468 n57 n109 n108 OAI211XLTS
XU534 n112 FE_DBTN23_n1484 destinationAddressbuffer[6][5] FE_DBTN24_n100
+ destinationAddressIn_WEST[5] AOI22X1TS
XU539 n111 FE_DBTN38_n3 destinationAddressIn_NORTH[5] n91
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU540 n2108 n1468 FE_DBTN192_destinationAddressInBuffer_EAST_5_ n112 n111
+ OAI211XLTS
XU541 n115 FE_DBTN23_n1484 destinationAddressbuffer[6][6] FE_DBTN24_n100
+ destinationAddressIn_WEST[6] AOI22X1TS
XU545 n114 FE_DBTN38_n3 destinationAddressIn_NORTH[6] n91
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU546 n2109 n1468 FE_DBTN195_destinationAddressInBuffer_EAST_6_ n115 n114
+ OAI211XLTS
XU547 n118 FE_DBTN23_n1484 destinationAddressbuffer[6][7] FE_DBTN24_n100
+ destinationAddressIn_WEST[7] AOI22X1TS
XU551 n117 FE_DBTN38_n3 destinationAddressIn_NORTH[7] n91
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU552 n2110 n1468 FE_DBTN198_destinationAddressInBuffer_EAST_7_ n118 n117
+ OAI211XLTS
XU553 n121 FE_DBTN23_n1484 destinationAddressbuffer[6][4] FE_DBTN24_n100
+ destinationAddressIn_WEST[4] AOI22X1TS
XU557 n120 FE_DBTN38_n3 destinationAddressIn_NORTH[4] n91
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU558 n2107 n1468 FE_DBTN189_destinationAddressInBuffer_EAST_4_ n121 n120
+ OAI211XLTS
XU559 n514 selectBit_EAST INVX2TS
XU562 n129 n128 FE_DBTN5_n1951 NAND2X1TS
XU563 n134 n131 n27 n129 FE_DBTN19_n221 AOI31XLTS
XU565 n974 n132 INVX2TS
XU572 n146 n1624 n1619 n136 NOR3XLTS
XU575 n139 FE_DBTN22_n1390 destinationAddressbuffer[3][10] n146
+ destinationAddressIn_EAST[10] AOI22X1TS
XU580 n138 n147 destinationAddressIn_NORTH[10] n137
+ destinationAddressIn_WEST[10] AOI22X1TS
XU581 n2149 n974 n140 n139 n138 OAI211XLTS
XU583 n143 FE_DBTN22_n1390 destinationAddressbuffer[3][11] n146
+ destinationAddressIn_EAST[11] AOI22X1TS
XU589 n142 n147 destinationAddressIn_NORTH[11] n137
+ destinationAddressIn_WEST[11] AOI22X1TS
XU590 n2150 n974 n144 n143 n142 OAI211XLTS
XU594 n149 FE_DBTN22_n1390 destinationAddressbuffer[3][9] n146
+ destinationAddressIn_EAST[9] AOI22X1TS
XU599 n148 n147 destinationAddressIn_NORTH[9] n137 destinationAddressIn_WEST[9]
+ AOI22X1TS
XU600 n2148 n974 n150 n149 n148 OAI211XLTS
XU601 n153 FE_DBTN22_n1390 destinationAddressbuffer[3][8] n146
+ destinationAddressIn_EAST[8] AOI22X1TS
XU603 n152 n147 destinationAddressIn_NORTH[8] n137 destinationAddressIn_WEST[8]
+ AOI22X1TS
XU604 n2147 n974 n154 n153 n152 OAI211XLTS
XU607 n157 FE_DBTN22_n1390 writeOutbuffer[3] n146 writeIn_EAST AOI22X1TS
XU611 n156 n147 writeIn_NORTH n137 writeIn_WEST AOI22X1TS
XU612 n2079 n974 n158 n157 n156 OAI211XLTS
XU615 n162 FE_DBTN22_n1390 destinationAddressbuffer[3][4] n146
+ destinationAddressIn_EAST[4] AOI22X1TS
XU618 n161 n147 destinationAddressIn_NORTH[4] n137 destinationAddressIn_WEST[4]
+ AOI22X1TS
XU619 n2143 n974 n163 n162 n161 OAI211XLTS
XU620 n168 FE_DBTN22_n1390 destinationAddressbuffer[3][6] n146
+ destinationAddressIn_EAST[6] AOI22X1TS
XU625 n167 n147 destinationAddressIn_NORTH[6] n137 destinationAddressIn_WEST[6]
+ AOI22X1TS
XU626 n2145 n974 n169 n168 n167 OAI211XLTS
XU627 n173 FE_DBTN22_n1390 destinationAddressbuffer[3][5] n146
+ destinationAddressIn_EAST[5] AOI22X1TS
XU630 n172 n147 destinationAddressIn_NORTH[5] n137 destinationAddressIn_WEST[5]
+ AOI22X1TS
XU631 n2144 n974 n174 n173 n172 OAI211XLTS
XU632 n178 FE_DBTN22_n1390 destinationAddressbuffer[3][7] n146
+ destinationAddressIn_EAST[7] AOI22X1TS
XU635 n177 n147 destinationAddressIn_NORTH[7] n137 destinationAddressIn_WEST[7]
+ AOI22X1TS
XU636 n2146 n974 n179 n178 n177 OAI211XLTS
XU637 n311 n268 INVX2TS
XU639 n1633 n386 n268 n385 NOR3XLTS
XU640 n182 FE_DBTN25_n1954 n389 FE_DBTN5_n1951 n1629 AOI31XLTS
XU641 n184 n185 n182 FE_DBTN19_n221 AOI21X1TS
XU642 n186 n184 n1637 NAND2X1TS
XU648 n198 n1634 n186 OR2X1TS
XU650 n189 FE_DBTN20_n1356 destinationAddressbuffer[2][9] FE_DBTN21_n198
+ destinationAddressIn_WEST[9] AOI22X1TS
XU654 n188 n191 destinationAddressIn_NORTH[9] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU655 n2160 n1357 FE_DBTN205_destinationAddressInBuffer_EAST_9_ n189 n188
+ OAI211XLTS
XU659 n193 FE_DBTN20_n1356 destinationAddressbuffer[2][8] FE_DBTN21_n198
+ destinationAddressIn_WEST[8] AOI22X1TS
XU663 n192 n191 destinationAddressIn_NORTH[8] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU664 n2159 n1357 FE_DBTN202_destinationAddressInBuffer_EAST_8_ n193 n192
+ OAI211XLTS
XU667 n197 FE_DBTN20_n1356 destinationAddressbuffer[2][10] FE_DBTN21_n198
+ destinationAddressIn_WEST[10] AOI22X1TS
XU672 n196 n191 destinationAddressIn_NORTH[10] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU673 n2161 n1357 FE_DBTN208_destinationAddressInBuffer_EAST_10_ n197 n196
+ OAI211XLTS
XU675 n203 FE_DBTN20_n1356 destinationAddressbuffer[2][11] FE_DBTN21_n198
+ destinationAddressIn_WEST[11] AOI22X1TS
XU677 n202 n191 destinationAddressIn_NORTH[11] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU678 n2162 n1357 FE_DBTN211_destinationAddressInBuffer_EAST_11_ n203 n202
+ OAI211XLTS
XU680 n205 FE_DBTN20_n1356 writeOutbuffer[2] FE_DBTN21_n198 writeIn_WEST
+ AOI22X1TS
XU681 n204 n191 writeIn_NORTH FE_DBTN37_n4 writeIn_SOUTH AOI22X1TS
XU682 n2080 n1357 n57 n205 n204 OAI211XLTS
XU684 n208 FE_DBTN20_n1356 destinationAddressbuffer[2][4] FE_DBTN21_n198
+ destinationAddressIn_WEST[4] AOI22X1TS
XU685 n207 n191 destinationAddressIn_NORTH[4] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU686 n2155 n1357 FE_DBTN189_destinationAddressInBuffer_EAST_4_ n208 n207
+ OAI211XLTS
XU687 n211 FE_DBTN20_n1356 destinationAddressbuffer[2][5] FE_DBTN21_n198
+ destinationAddressIn_WEST[5] AOI22X1TS
XU689 n210 n191 destinationAddressIn_NORTH[5] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU690 n2156 n1357 FE_DBTN192_destinationAddressInBuffer_EAST_5_ n211 n210
+ OAI211XLTS
XU691 n214 FE_DBTN20_n1356 destinationAddressbuffer[2][6] FE_DBTN21_n198
+ destinationAddressIn_WEST[6] AOI22X1TS
XU692 n213 n191 destinationAddressIn_NORTH[6] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU693 n2157 n1357 FE_DBTN195_destinationAddressInBuffer_EAST_6_ n214 n213
+ OAI211XLTS
XU694 n217 FE_DBTN20_n1356 destinationAddressbuffer[2][7] FE_DBTN21_n198
+ destinationAddressIn_WEST[7] AOI22X1TS
XU695 n216 n191 destinationAddressIn_NORTH[7] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU696 n2158 n1357 FE_DBTN198_destinationAddressInBuffer_EAST_7_ n217 n216
+ OAI211XLTS
XU699 n224 n226 n1594 n222 FE_DBTN19_n221 AOI31XLTS
XU701 n227 n224 n1604 NAND2X1TS
XU702 n1441 n223 INVX2TS
XU708 n241 n1601 n227 OR2X1TS
XU712 n231 FE_DBTN16_n1450 destinationAddressbuffer[5][8] FE_DBTN18_n241
+ destinationAddressIn_WEST[8] AOI22X1TS
XU713 n1597 n1594 INVX2TS
XU715 n253 n1594 n228 OR2X1TS
XU717 n230 FE_DBTN39_n2 destinationAddressIn_NORTH[8] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU718 n2123 n1441 FE_DBTN202_destinationAddressInBuffer_EAST_8_ n231 n230
+ OAI211XLTS
XU720 n234 FE_DBTN16_n1450 destinationAddressbuffer[5][11] FE_DBTN18_n241
+ destinationAddressIn_WEST[11] AOI22X1TS
XU721 n233 FE_DBTN39_n2 destinationAddressIn_NORTH[11] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU722 n2126 n1441 FE_DBTN211_destinationAddressInBuffer_EAST_11_ n234 n233
+ OAI211XLTS
XU725 n239 FE_DBTN16_n1450 destinationAddressbuffer[5][10] FE_DBTN18_n241
+ destinationAddressIn_WEST[10] AOI22X1TS
XU729 n238 FE_DBTN39_n2 destinationAddressIn_NORTH[10] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU730 n2125 n1441 FE_DBTN208_destinationAddressInBuffer_EAST_10_ n239 n238
+ OAI211XLTS
XU732 n244 FE_DBTN16_n1450 destinationAddressbuffer[5][9] FE_DBTN18_n241
+ destinationAddressIn_WEST[9] AOI22X1TS
XU736 n243 FE_DBTN39_n2 destinationAddressIn_NORTH[9] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU737 n2124 n1441 FE_DBTN205_destinationAddressInBuffer_EAST_9_ n244 n243
+ OAI211XLTS
XU739 n248 FE_DBTN16_n1450 writeOutbuffer[5] FE_DBTN18_n241 writeIn_WEST
+ AOI22X1TS
XU741 n247 FE_DBTN39_n2 writeIn_NORTH FE_DBTN17_n253 writeIn_SOUTH AOI22X1TS
XU742 n2077 n1441 n57 n248 n247 OAI211XLTS
XU744 n251 FE_DBTN16_n1450 destinationAddressbuffer[5][4] FE_DBTN18_n241
+ destinationAddressIn_WEST[4] AOI22X1TS
XU746 n250 FE_DBTN39_n2 destinationAddressIn_NORTH[4] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU747 n2119 n1441 FE_DBTN189_destinationAddressInBuffer_EAST_4_ n251 n250
+ OAI211XLTS
XU748 n256 FE_DBTN16_n1450 destinationAddressbuffer[5][5] FE_DBTN18_n241
+ destinationAddressIn_WEST[5] AOI22X1TS
XU749 n255 FE_DBTN39_n2 destinationAddressIn_NORTH[5] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU750 n2120 n1441 FE_DBTN192_destinationAddressInBuffer_EAST_5_ n256 n255
+ OAI211XLTS
XU751 n260 FE_DBTN16_n1450 destinationAddressbuffer[5][7] FE_DBTN18_n241
+ destinationAddressIn_WEST[7] AOI22X1TS
XU753 n259 FE_DBTN39_n2 destinationAddressIn_NORTH[7] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU754 n2122 n1441 FE_DBTN198_destinationAddressInBuffer_EAST_7_ n260 n259
+ OAI211XLTS
XU755 n264 FE_DBTN16_n1450 destinationAddressbuffer[5][6] FE_DBTN18_n241
+ destinationAddressIn_WEST[6] AOI22X1TS
XU756 n263 FE_DBTN39_n2 destinationAddressIn_NORTH[6] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU757 n2121 n1441 FE_DBTN195_destinationAddressInBuffer_EAST_6_ n264 n263
+ OAI211XLTS
XU758 n271 FE_DBTN15_n1952 n389 FE_DBTN9_n1949 n1608 AOI31XLTS
XU759 n275 n276 n271 FE_DBTN19_n221 AOI21X1TS
XU760 n277 n275 n1616 NAND2X1TS
XU761 n1408 n273 INVX2TS
XU768 n289 n1612 n277 OR2X1TS
XU770 n281 FE_DBTN13_n1419 destinationAddressbuffer[4][10] FE_DBTN14_n289
+ destinationAddressIn_WEST[10] AOI22X1TS
XU774 n280 FE_DBTN33_n9 destinationAddressIn_SOUTH[10] FE_DBTN31_n11
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU775 n2137 n1408 FE_DBTN208_destinationAddressInBuffer_EAST_10_ n281 n280
+ OAI211XLTS
XU778 n284 FE_DBTN13_n1419 destinationAddressbuffer[4][9] FE_DBTN14_n289
+ destinationAddressIn_WEST[9] AOI22X1TS
XU783 n283 FE_DBTN33_n9 destinationAddressIn_SOUTH[9] FE_DBTN31_n11
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU784 n2136 n1408 FE_DBTN205_destinationAddressInBuffer_EAST_9_ n284 n283
+ OAI211XLTS
XU786 n288 FE_DBTN13_n1419 destinationAddressbuffer[4][11] FE_DBTN14_n289
+ destinationAddressIn_WEST[11] AOI22X1TS
XU789 n287 FE_DBTN33_n9 destinationAddressIn_SOUTH[11] FE_DBTN31_n11
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU790 n2138 n1408 FE_DBTN211_destinationAddressInBuffer_EAST_11_ n288 n287
+ OAI211XLTS
XU794 n293 FE_DBTN13_n1419 destinationAddressbuffer[4][8] FE_DBTN14_n289
+ destinationAddressIn_WEST[8] AOI22X1TS
XU797 n292 FE_DBTN33_n9 destinationAddressIn_SOUTH[8] FE_DBTN31_n11
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU798 n2135 n1408 FE_DBTN202_destinationAddressInBuffer_EAST_8_ n293 n292
+ OAI211XLTS
XU800 n296 FE_DBTN13_n1419 writeOutbuffer[4] FE_DBTN14_n289 writeIn_WEST
+ AOI22X1TS
XU802 n295 FE_DBTN33_n9 writeIn_SOUTH FE_DBTN31_n11 writeIn_NORTH AOI22X1TS
XU803 n2078 n1408 n57 n296 n295 OAI211XLTS
XU805 n299 FE_DBTN13_n1419 destinationAddressbuffer[4][4] FE_DBTN14_n289
+ destinationAddressIn_WEST[4] AOI22X1TS
XU806 n298 FE_DBTN33_n9 destinationAddressIn_SOUTH[4] FE_DBTN31_n11
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU807 n2131 n1408 FE_DBTN189_destinationAddressInBuffer_EAST_4_ n299 n298
+ OAI211XLTS
XU808 n302 FE_DBTN13_n1419 destinationAddressbuffer[4][5] FE_DBTN14_n289
+ destinationAddressIn_WEST[5] AOI22X1TS
XU810 n301 FE_DBTN33_n9 destinationAddressIn_SOUTH[5] FE_DBTN31_n11
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU811 n2132 n1408 FE_DBTN192_destinationAddressInBuffer_EAST_5_ n302 n301
+ OAI211XLTS
XU812 n305 FE_DBTN13_n1419 destinationAddressbuffer[4][6] FE_DBTN14_n289
+ destinationAddressIn_WEST[6] AOI22X1TS
XU814 n304 FE_DBTN33_n9 destinationAddressIn_SOUTH[6] FE_DBTN31_n11
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU815 n2133 n1408 FE_DBTN195_destinationAddressInBuffer_EAST_6_ n305 n304
+ OAI211XLTS
XU816 n309 FE_DBTN13_n1419 destinationAddressbuffer[4][7] FE_DBTN14_n289
+ destinationAddressIn_WEST[7] AOI22X1TS
XU817 n308 FE_DBTN33_n9 destinationAddressIn_SOUTH[7] FE_DBTN31_n11
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU818 n2134 n1408 FE_DBTN198_destinationAddressInBuffer_EAST_7_ n309 n308
+ OAI211XLTS
XU819 n313 n19 FE_DBTN9_n1949 FE_DBTN5_n1951 n1643 AOI31XLTS
XU820 n318 n321 n313 FE_DBTN19_n221 AOI21X1TS
XU821 n322 n318 n1651 NAND2X1TS
XU822 n1098 n315 INVX2TS
XU830 n343 n1647 n322 OR2X1TS
XU834 n328 FE_DBTN10_n356 destinationAddressbuffer[1][8] FE_DBTN11_n343
+ destinationAddressIn_WEST[8] AOI22X1TS
XU835 n338 n1643 n323 NOR2XLTS
XU839 n327 n338 destinationAddressIn_NORTH[8] n324
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU840 n2171 n1098 FE_DBTN202_destinationAddressInBuffer_EAST_8_ n328 n327
+ OAI211XLTS
XU843 n335 FE_DBTN10_n356 destinationAddressbuffer[1][10] FE_DBTN11_n343
+ destinationAddressIn_WEST[10] AOI22X1TS
XU847 n334 n338 destinationAddressIn_NORTH[10] n324
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU848 n2173 n1098 FE_DBTN208_destinationAddressInBuffer_EAST_10_ n335 n334
+ OAI211XLTS
XU850 n342 FE_DBTN10_n356 destinationAddressbuffer[1][9] FE_DBTN11_n343
+ destinationAddressIn_WEST[9] AOI22X1TS
XU853 n341 n338 destinationAddressIn_NORTH[9] n324
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU854 n2172 n1098 FE_DBTN205_destinationAddressInBuffer_EAST_9_ n342 n341
+ OAI211XLTS
XU856 n350 FE_DBTN10_n356 destinationAddressbuffer[1][11] FE_DBTN11_n343
+ destinationAddressIn_WEST[11] AOI22X1TS
XU859 n349 n338 destinationAddressIn_NORTH[11] n324
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU860 n2174 n1098 FE_DBTN211_destinationAddressInBuffer_EAST_11_ n350 n349
+ OAI211XLTS
XU862 n355 FE_DBTN10_n356 writeOutbuffer[1] FE_DBTN11_n343 writeIn_WEST
+ AOI22X1TS
XU864 n354 n338 writeIn_NORTH n324 writeIn_SOUTH AOI22X1TS
XU865 n2081 n1098 n57 n355 n354 OAI211XLTS
XU867 n362 FE_DBTN10_n356 destinationAddressbuffer[1][4] FE_DBTN11_n343
+ destinationAddressIn_WEST[4] AOI22X1TS
XU868 n361 n338 destinationAddressIn_NORTH[4] n324
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU869 n2167 n1098 FE_DBTN189_destinationAddressInBuffer_EAST_4_ n362 n361
+ OAI211XLTS
XU870 n368 FE_DBTN10_n356 destinationAddressbuffer[1][6] FE_DBTN11_n343
+ destinationAddressIn_WEST[6] AOI22X1TS
XU871 n367 n338 destinationAddressIn_NORTH[6] n324
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU872 n2169 n1098 FE_DBTN195_destinationAddressInBuffer_EAST_6_ n368 n367
+ OAI211XLTS
XU873 n375 FE_DBTN10_n356 destinationAddressbuffer[1][5] FE_DBTN11_n343
+ destinationAddressIn_WEST[5] AOI22X1TS
XU876 n374 n338 destinationAddressIn_NORTH[5] n324
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU877 n2168 n1098 FE_DBTN192_destinationAddressInBuffer_EAST_5_ n375 n374
+ OAI211XLTS
XU878 n382 FE_DBTN10_n356 destinationAddressbuffer[1][7] FE_DBTN11_n343
+ destinationAddressIn_WEST[7] AOI22X1TS
XU879 n381 n338 destinationAddressIn_NORTH[7] n324
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU880 n2170 n1098 FE_DBTN198_destinationAddressInBuffer_EAST_7_ n382 n381
+ OAI211XLTS
XU881 n391 n389 FE_DBTN9_n1949 FE_DBTN5_n1951 n1656 AOI31XLTS
XU882 n396 n398 n391 FE_DBTN19_n221 AOI21X1TS
XU883 n399 n396 n1664 NAND2X1TS
XU889 n415 n1661 n399 OR2X1TS
XU891 n404 FE_DBTN6_n425 destinationAddressbuffer[0][10] FE_DBTN7_n415
+ destinationAddressIn_WEST[10] AOI22X1TS
XU894 n403 FE_DBTN35_n6 destinationAddressIn_SOUTH[10] FE_DBTN36_n5
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU895 n2185 n1 FE_DBTN208_destinationAddressInBuffer_EAST_10_ n404 n403
+ OAI211XLTS
XU900 n409 FE_DBTN6_n425 destinationAddressbuffer[0][11] FE_DBTN7_n415
+ destinationAddressIn_WEST[11] AOI22X1TS
XU901 n408 FE_DBTN35_n6 destinationAddressIn_SOUTH[11] FE_DBTN36_n5
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU902 n2186 n1 FE_DBTN211_destinationAddressInBuffer_EAST_11_ n409 n408
+ OAI211XLTS
XU905 n414 FE_DBTN6_n425 destinationAddressbuffer[0][8] FE_DBTN7_n415
+ destinationAddressIn_WEST[8] AOI22X1TS
XU908 n413 FE_DBTN35_n6 destinationAddressIn_SOUTH[8] FE_DBTN36_n5
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU909 n2183 n1 FE_DBTN202_destinationAddressInBuffer_EAST_8_ n414 n413
+ OAI211XLTS
XU911 n421 FE_DBTN6_n425 destinationAddressbuffer[0][9] FE_DBTN7_n415
+ destinationAddressIn_WEST[9] AOI22X1TS
XU918 n420 FE_DBTN35_n6 destinationAddressIn_SOUTH[9] FE_DBTN36_n5
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU919 n2184 n1 FE_DBTN205_destinationAddressInBuffer_EAST_9_ n421 n420
+ OAI211XLTS
XU921 n424 FE_DBTN6_n425 writeOutbuffer[0] FE_DBTN7_n415 writeIn_WEST AOI22X1TS
XU923 n423 FE_DBTN35_n6 writeIn_SOUTH FE_DBTN36_n5 writeIn_NORTH AOI22X1TS
XU924 n2082 n1 n57 n424 n423 OAI211XLTS
XU927 n428 FE_DBTN6_n425 destinationAddressbuffer[0][4] FE_DBTN7_n415
+ destinationAddressIn_WEST[4] AOI22X1TS
XU928 n427 FE_DBTN35_n6 destinationAddressIn_SOUTH[4] FE_DBTN36_n5
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU929 n2179 n1 FE_DBTN189_destinationAddressInBuffer_EAST_4_ n428 n427
+ OAI211XLTS
XU930 n433 FE_DBTN6_n425 destinationAddressbuffer[0][5] FE_DBTN7_n415
+ destinationAddressIn_WEST[5] AOI22X1TS
XU931 n432 FE_DBTN35_n6 destinationAddressIn_SOUTH[5] FE_DBTN36_n5
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU932 n2180 n1 FE_DBTN192_destinationAddressInBuffer_EAST_5_ n433 n432
+ OAI211XLTS
XU933 n437 FE_DBTN6_n425 destinationAddressbuffer[0][6] FE_DBTN7_n415
+ destinationAddressIn_WEST[6] AOI22X1TS
XU934 n436 FE_DBTN35_n6 destinationAddressIn_SOUTH[6] FE_DBTN36_n5
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU935 n2181 n1 FE_DBTN195_destinationAddressInBuffer_EAST_6_ n437 n436
+ OAI211XLTS
XU936 n443 FE_DBTN6_n425 destinationAddressbuffer[0][7] FE_DBTN7_n415
+ destinationAddressIn_WEST[7] AOI22X1TS
XU937 n442 FE_DBTN35_n6 destinationAddressIn_SOUTH[7] FE_DBTN36_n5
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU938 n2182 n1 FE_DBTN198_destinationAddressInBuffer_EAST_7_ n443 n442
+ OAI211XLTS
XU941 n532 n1947 INVX2TS
XU942 n530 FE_DBTN3_n1953 n532 NAND2X1TS
XU943 n504 FE_DBTN3_n1953 n1948 n530 OAI21XLTS
XU946 n840 n530 FE_DBTN1_n1944 NOR2XLTS
XU949 n501 n530 FE_DBTN1_n1944 n840 AOI21X1TS
XU950 n447 FE_DBTN25_n1954 n504 FE_DBTN5_n1951 n501 OAI22X1TS
XU951 n451 n504 FE_DBTN25_n1954 FE_DBTN5_n1951 n501 n447 AOI221XLTS
XU953 n449 n1941 INVX2TS
XU954 n463 FE_DBTN12_n1950 n449 NAND2X1TS
XU955 n467 FE_DBTN12_n1950 n1953 n463 OAI21XLTS
XU956 n452 n451 n467 n1943 AOI21X1TS
XU957 n505 n494 n1943 NAND2X1TS
XU958 n499 reset FE_DBTN19_n221 NOR2XLTS
XU962 n457 FE_DBTN15_n1952 FE_DBTN1_n1944 FE_DBTN2_n1945 FE_DBTN5_n1951
+ AOI22X1TS
XU964 n474 n477 INVX2TS
XU965 n473 FE_DBTN3_n1953 FE_DBTN8_n1946 n459 AOI21X1TS
XU966 n477 n479 n466 n465 ADDHXLTS
XU967 n468 n479 INVX2TS
XU968 n471 n469 n468 n467 AOI21X1TS
XU969 n470 n469 n468 n475 n474 OAI22X1TS
XU970 n472 n478 n471 n470 AOI21X1TS
XU971 n476 n475 n474 n473 n472 AOI211X1TS
XU972 n480 n476 INVX2TS
XU973 n484 n480 n477 NAND2X1TS
XU974 n483 FE_DBTN15_n1952 n481 XNOR2X1TS
XU975 n498 n484 n483 XOR2X1TS
XU976 n492 n498 INVX2TS
XU978 n488 n495 FE_DBTN12_n1950 n485 ADDHXLTS
XU979 n489 n1948 n496 XNOR2X1TS
XU980 N2624 n499 n493 n1955 n505 OAI2BB2XLTS
XU981 n503 n494 n1942 NAND2X1TS
XU982 n1964 n1941 n505 n503 n449 AOI22X1TS
XU983 n502 n501 INVX2TS
XU984 n1969 FE_DBTN1_n1944 n505 n502 n503 OAI22X1TS
XU985 n1970 n1947 n505 n504 n503 OAI22X1TS
XU992 n522 n1942 INVX2TS
XU993 n510 n540 n522 NAND2X1TS
XU994 n614 readReady selectBit_EAST n456 n510 NOR4XLTS
XU998 n543 readIn_SOUTH n545 readIn_WEST n614 AOI22X1TS
XU1003 n647 selectBit_WEST readReady n514 n510 NOR4XLTS
XU1007 n542 readIn_NORTH n693 readIn_EAST n647 AOI22X1TS
XU1008 n518 selectBit_EAST readReady n456 NOR3XLTS
XU1009 n517 selectBit_WEST readReady n514 NOR3XLTS
XU1010 n521 n518 n539 n517 n540 OAI31X1TS
XU1011 n676 n522 n521 n520 n519 NAND4XLTS
XU1016 n721 FE_DBTN3_n1953 FE_DBTN2_n1945 n1947 NOR3XLTS
XU1019 n695 FE_DBTN3_n1953 n1948 FE_DBTN2_n1945 NOR3XLTS
XU1022 n537 readOutbuffer[2] n721 readOutbuffer[0] n695 AOI22X1TS
XU1023 n722 FE_DBTN3_n1953 n1947 FE_DBTN1_n1944 NOR3XLTS
XU1026 n696 FE_DBTN3_n1953 n532 FE_DBTN1_n1944 NOR3XLTS
XU1029 n536 readOutbuffer[6] n722 readOutbuffer[4] n696 AOI22X1TS
XU1030 n723 FE_DBTN2_n1945 n530 NOR2XLTS
XU1033 n697 n532 FE_DBTN2_n1945 n1953 NOR3XLTS
XU1036 n535 readOutbuffer[3] n723 readOutbuffer[1] n697 AOI22X1TS
XU1038 n863 n1948 n449 FE_DBTN1_n1944 NOR3XLTS
XU1041 n534 readOutbuffer[7] n840 readOutbuffer[5] n863 AOI22X1TS
XU1042 n538 n537 n536 n535 n534 NAND4XLTS
XU1043 n541 readOut n553 n1942 n538 AOI22X1TS
XU1045 n556 writeIn_EAST n647 writeIn_WEST n614 AOI22X1TS
XU1048 n555 writeIn_NORTH n693 writeIn_SOUTH n545 AOI22X1TS
XU1049 n551 writeOutbuffer[2] n721 writeOutbuffer[0] n695 AOI22X1TS
XU1050 n550 writeOutbuffer[6] n722 writeOutbuffer[4] n696 AOI22X1TS
XU1051 n549 writeOutbuffer[3] n723 writeOutbuffer[1] n697 AOI22X1TS
XU1052 n548 writeOutbuffer[7] n840 writeOutbuffer[5] n863 AOI22X1TS
XU1053 n552 n551 n550 n549 n548 NAND4XLTS
XU1054 n554 writeOut n553 n1942 n552 AOI22X1TS
XU1059 n565 requesterAddressIn_NORTH[0] n693 requesterAddressIn_EAST[0] n647
+ AOI22X1TS
XU1065 n564 requesterAddressIn_SOUTH[0] n545 requesterAddressIn_WEST[0] n614
+ AOI22X1TS
XU1068 n560 requesterAddressbuffer[2][0] n721 requesterAddressbuffer[0][0] n695
+ AOI22X1TS
XU1069 n559 requesterAddressbuffer[6][0] n722 requesterAddressbuffer[4][0] n696
+ AOI22X1TS
XU1070 n558 requesterAddressbuffer[3][0] n723 requesterAddressbuffer[1][0] n697
+ AOI22X1TS
XU1073 n557 requesterAddressbuffer[7][0] n840 requesterAddressbuffer[5][0] n863
+ AOI22X1TS
XU1074 n561 n560 n559 n558 n557 NAND4XLTS
XU1075 n563 requesterAddressOut[0] FE_DBTN4_n676 n1942 n561 AOI22X1TS
XU1079 n609 readRequesterAddress[0] FE_DBTN0_n562 NAND2X1TS
XU1083 n582 requesterAddressIn_NORTH[1] n693 requesterAddressIn_EAST[1] n647
+ AOI22X1TS
XU1089 n581 requesterAddressIn_SOUTH[1] n545 requesterAddressIn_WEST[1] n614
+ AOI22X1TS
XU1090 n578 requesterAddressbuffer[2][1] n721 requesterAddressbuffer[0][1] n695
+ AOI22X1TS
XU1091 n577 requesterAddressbuffer[6][1] n722 requesterAddressbuffer[4][1] n696
+ AOI22X1TS
XU1092 n576 requesterAddressbuffer[3][1] n723 requesterAddressbuffer[1][1] n697
+ AOI22X1TS
XU1093 n575 requesterAddressbuffer[7][1] n840 requesterAddressbuffer[5][1] n863
+ AOI22X1TS
XU1094 n579 n578 n577 n576 n575 NAND4XLTS
XU1095 n580 requesterAddressOut[1] FE_DBTN4_n676 n1942 n579 AOI22X1TS
XU1098 n624 readRequesterAddress[1] FE_DBTN0_n562 NAND2X1TS
XU1103 n590 requesterAddressIn_NORTH[2] n693 requesterAddressIn_EAST[2] n647
+ AOI22X1TS
XU1108 n589 requesterAddressIn_SOUTH[2] n545 requesterAddressIn_WEST[2] n614
+ AOI22X1TS
XU1111 n586 requesterAddressbuffer[2][2] n721 requesterAddressbuffer[0][2] n695
+ AOI22X1TS
XU1113 n585 requesterAddressbuffer[6][2] n722 requesterAddressbuffer[4][2] n696
+ AOI22X1TS
XU1115 n584 requesterAddressbuffer[3][2] n723 requesterAddressbuffer[1][2] n697
+ AOI22X1TS
XU1117 n583 requesterAddressbuffer[7][2] n840 requesterAddressbuffer[5][2] n863
+ AOI22X1TS
XU1118 n587 n586 n585 n584 n583 NAND4XLTS
XU1119 n588 requesterAddressOut[2] FE_DBTN4_n676 n1942 n587 AOI22X1TS
XU1122 n643 readRequesterAddress[2] FE_DBTN0_n562 NAND2X1TS
XU1126 n601 requesterAddressIn_NORTH[3] n693 requesterAddressIn_EAST[3] n647
+ AOI22X1TS
XU1131 n600 requesterAddressIn_SOUTH[3] n545 requesterAddressIn_WEST[3] n614
+ AOI22X1TS
XU1132 n595 requesterAddressbuffer[2][3] n721 requesterAddressbuffer[0][3] n695
+ AOI22X1TS
XU1133 n594 requesterAddressbuffer[6][3] n722 requesterAddressbuffer[4][3] n696
+ AOI22X1TS
XU1134 n593 requesterAddressbuffer[3][3] n723 requesterAddressbuffer[1][3] n697
+ AOI22X1TS
XU1136 n592 requesterAddressbuffer[7][3] n840 requesterAddressbuffer[5][3] n863
+ AOI22X1TS
XU1137 n596 n595 n594 n593 n592 NAND4XLTS
XU1138 n599 requesterAddressOut[3] FE_DBTN4_n676 n1942 n596 AOI22X1TS
XU1141 n655 readRequesterAddress[3] FE_DBTN0_n562 NAND2X1TS
XU1145 n612 destinationAddressIn_NORTH[0] n693 destinationAddressIn_EAST[0]
+ n647 AOI22X1TS
XU1148 n611 destinationAddressIn_SOUTH[0] n545 destinationAddressIn_WEST[0]
+ n614 AOI22X1TS
XU1150 n607 destinationAddressbuffer[2][0] n721 destinationAddressbuffer[0][0]
+ n695 AOI22X1TS
XU1151 n606 destinationAddressbuffer[6][0] n722 destinationAddressbuffer[4][0]
+ n696 AOI22X1TS
XU1152 n605 destinationAddressbuffer[3][0] n723 destinationAddressbuffer[1][0]
+ n697 AOI22X1TS
XU1153 n604 destinationAddressbuffer[7][0] n840 destinationAddressbuffer[5][0]
+ n863 AOI22X1TS
XU1154 n608 n607 n606 n605 n604 NAND4XLTS
XU1155 n610 destinationAddressOut[0] FE_DBTN4_n676 n1942 n608 AOI22X1TS
XU1159 n627 destinationAddressIn_NORTH[1] n693 destinationAddressIn_EAST[1]
+ n647 AOI22X1TS
XU1162 n626 destinationAddressIn_SOUTH[1] n545 destinationAddressIn_WEST[1]
+ n614 AOI22X1TS
XU1163 n622 destinationAddressbuffer[2][1] n721 destinationAddressbuffer[0][1]
+ n695 AOI22X1TS
XU1164 n621 destinationAddressbuffer[6][1] n722 destinationAddressbuffer[4][1]
+ n696 AOI22X1TS
XU1165 n620 destinationAddressbuffer[3][1] n723 destinationAddressbuffer[1][1]
+ n697 AOI22X1TS
XU1166 n619 destinationAddressbuffer[7][1] n840 destinationAddressbuffer[5][1]
+ n863 AOI22X1TS
XU1167 n623 n622 n621 n620 n619 NAND4XLTS
XU1168 n625 destinationAddressOut[1] FE_DBTN4_n676 n1942 n623 AOI22X1TS
XU1173 n646 destinationAddressIn_NORTH[2] n693 destinationAddressIn_EAST[2]
+ n647 AOI22X1TS
XU1178 n645 destinationAddressIn_SOUTH[2] n545 destinationAddressIn_WEST[2]
+ n614 AOI22X1TS
XU1182 n641 destinationAddressbuffer[2][2] n721 destinationAddressbuffer[0][2]
+ n695 AOI22X1TS
XU1185 n640 destinationAddressbuffer[6][2] n722 destinationAddressbuffer[4][2]
+ n696 AOI22X1TS
XU1188 n639 destinationAddressbuffer[3][2] n723 destinationAddressbuffer[1][2]
+ n697 AOI22X1TS
XU1190 n638 destinationAddressbuffer[7][2] n840 destinationAddressbuffer[5][2]
+ n863 AOI22X1TS
XU1191 n642 n641 n640 n639 n638 NAND4XLTS
XU1192 n644 destinationAddressOut[2] FE_DBTN4_n676 n1942 n642 AOI22X1TS
XU1196 n658 destinationAddressIn_NORTH[3] n693 destinationAddressIn_EAST[3]
+ n647 AOI22X1TS
XU1199 n657 destinationAddressIn_SOUTH[3] n545 destinationAddressIn_WEST[3]
+ n614 AOI22X1TS
XU1200 n652 destinationAddressbuffer[2][3] n721 destinationAddressbuffer[0][3]
+ n695 AOI22X1TS
XU1201 n651 destinationAddressbuffer[6][3] n722 destinationAddressbuffer[4][3]
+ n696 AOI22X1TS
XU1202 n650 destinationAddressbuffer[3][3] n723 destinationAddressbuffer[1][3]
+ n697 AOI22X1TS
XU1203 n649 destinationAddressbuffer[7][3] n840 destinationAddressbuffer[5][3]
+ n863 AOI22X1TS
XU1204 n653 n652 n651 n650 n649 NAND4XLTS
XU1205 n656 destinationAddressOut[3] FE_DBTN4_n676 n1942 n653 AOI22X1TS
XU1206 n669 destinationAddressIn_EAST[4] n647 destinationAddressIn_WEST[4] n614
+ AOI22X1TS
XU1207 n668 destinationAddressIn_NORTH[4] n693 destinationAddressIn_SOUTH[4]
+ n545 AOI22X1TS
XU1208 n770 n1943 INVX2TS
XU1210 n665 destinationAddressbuffer[2][4] n721 destinationAddressbuffer[0][4]
+ n695 AOI22X1TS
XU1211 n664 destinationAddressbuffer[6][4] n722 destinationAddressbuffer[4][4]
+ n696 AOI22X1TS
XU1212 n663 destinationAddressbuffer[3][4] n723 destinationAddressbuffer[1][4]
+ n697 AOI22X1TS
XU1214 n662 destinationAddressbuffer[7][4] n840 destinationAddressbuffer[5][4]
+ n863 AOI22X1TS
XU1215 n666 n665 n664 n663 n662 NAND4XLTS
XU1216 n667 destinationAddressOut[4] FE_DBTN4_n676 n770 n666 AOI22X1TS
XU1218 n691 destinationAddressIn_EAST[5] n647 destinationAddressIn_WEST[5] n614
+ AOI22X1TS
XU1220 n690 destinationAddressIn_NORTH[5] n693 destinationAddressIn_SOUTH[5]
+ n545 AOI22X1TS
XU1222 n687 destinationAddressbuffer[2][5] n721 destinationAddressbuffer[0][5]
+ n695 AOI22X1TS
XU1223 n686 destinationAddressbuffer[6][5] n722 destinationAddressbuffer[4][5]
+ n696 AOI22X1TS
XU1224 n685 destinationAddressbuffer[3][5] n723 destinationAddressbuffer[1][5]
+ n697 AOI22X1TS
XU1225 n684 destinationAddressbuffer[7][5] n840 destinationAddressbuffer[5][5]
+ n863 AOI22X1TS
XU1226 n688 n687 n686 n685 n684 NAND4XLTS
XU1227 n689 destinationAddressOut[5] FE_DBTN4_n676 n770 n688 AOI22X1TS
XU1229 n706 destinationAddressIn_EAST[6] n647 destinationAddressIn_WEST[6] n614
+ AOI22X1TS
XU1231 n705 destinationAddressIn_NORTH[6] n693 destinationAddressIn_SOUTH[6]
+ n545 AOI22X1TS
XU1234 n701 destinationAddressbuffer[2][6] n721 destinationAddressbuffer[0][6]
+ n695 AOI22X1TS
XU1237 n700 destinationAddressbuffer[6][6] n722 destinationAddressbuffer[4][6]
+ n696 AOI22X1TS
XU1240 n699 destinationAddressbuffer[3][6] n723 destinationAddressbuffer[1][6]
+ n697 AOI22X1TS
XU1243 n698 destinationAddressbuffer[7][6] n840 destinationAddressbuffer[5][6]
+ n863 AOI22X1TS
XU1244 n702 n701 n700 n699 n698 NAND4XLTS
XU1245 n704 destinationAddressOut[6] FE_DBTN4_n676 n770 n702 AOI22X1TS
XU1246 n717 destinationAddressIn_EAST[7] n647 destinationAddressIn_WEST[7] n614
+ AOI22X1TS
XU1247 n716 destinationAddressIn_NORTH[7] n693 destinationAddressIn_SOUTH[7]
+ n545 AOI22X1TS
XU1249 n713 destinationAddressbuffer[2][7] n721 destinationAddressbuffer[0][7]
+ n695 AOI22X1TS
XU1250 n712 destinationAddressbuffer[6][7] n722 destinationAddressbuffer[4][7]
+ n696 AOI22X1TS
XU1251 n711 destinationAddressbuffer[3][7] n723 destinationAddressbuffer[1][7]
+ n697 AOI22X1TS
XU1252 n710 destinationAddressbuffer[7][7] n840 destinationAddressbuffer[5][7]
+ n863 AOI22X1TS
XU1253 n714 n713 n712 n711 n710 NAND4XLTS
XU1254 n715 destinationAddressOut[7] FE_DBTN4_n676 n770 n714 AOI22X1TS
XU1255 n731 destinationAddressIn_EAST[8] n647 destinationAddressIn_WEST[8] n614
+ AOI22X1TS
XU1256 n730 destinationAddressIn_NORTH[8] n693 destinationAddressIn_SOUTH[8]
+ n545 AOI22X1TS
XU1258 n727 destinationAddressbuffer[2][8] n721 destinationAddressbuffer[0][8]
+ n695 AOI22X1TS
XU1260 n726 destinationAddressbuffer[6][8] n722 destinationAddressbuffer[4][8]
+ n696 AOI22X1TS
XU1262 n725 destinationAddressbuffer[3][8] n723 destinationAddressbuffer[1][8]
+ n697 AOI22X1TS
XU1263 n724 destinationAddressbuffer[7][8] n840 destinationAddressbuffer[5][8]
+ n863 AOI22X1TS
XU1264 n728 n727 n726 n725 n724 NAND4XLTS
XU1265 n729 destinationAddressOut[8] FE_DBTN4_n676 n770 n728 AOI22X1TS
XU1266 n749 destinationAddressIn_EAST[9] n647 destinationAddressIn_WEST[9] n614
+ AOI22X1TS
XU1267 n748 destinationAddressIn_NORTH[9] n693 destinationAddressIn_SOUTH[9]
+ n545 AOI22X1TS
XU1268 n744 destinationAddressbuffer[2][9] n721 destinationAddressbuffer[0][9]
+ n695 AOI22X1TS
XU1269 n743 destinationAddressbuffer[6][9] n722 destinationAddressbuffer[4][9]
+ n696 AOI22X1TS
XU1270 n742 destinationAddressbuffer[3][9] n723 destinationAddressbuffer[1][9]
+ n697 AOI22X1TS
XU1271 n741 destinationAddressbuffer[7][9] n840 destinationAddressbuffer[5][9]
+ n863 AOI22X1TS
XU1272 n745 n744 n743 n742 n741 NAND4XLTS
XU1273 n747 destinationAddressOut[9] FE_DBTN4_n676 n770 n745 AOI22X1TS
XU1275 n764 destinationAddressIn_EAST[10] n647 destinationAddressIn_WEST[10]
+ n614 AOI22X1TS
XU1277 n763 destinationAddressIn_NORTH[10] n693 destinationAddressIn_SOUTH[10]
+ n545 AOI22X1TS
XU1280 n759 destinationAddressbuffer[2][10] n721
+ destinationAddressbuffer[0][10] n695 AOI22X1TS
XU1283 n758 destinationAddressbuffer[6][10] n722
+ destinationAddressbuffer[4][10] n696 AOI22X1TS
XU1286 n757 destinationAddressbuffer[3][10] n723
+ destinationAddressbuffer[1][10] n697 AOI22X1TS
XU1288 n756 destinationAddressbuffer[7][10] n840
+ destinationAddressbuffer[5][10] n863 AOI22X1TS
XU1289 n760 n759 n758 n757 n756 NAND4XLTS
XU1290 n762 destinationAddressOut[10] FE_DBTN4_n676 n770 n760 AOI22X1TS
XU1291 n778 destinationAddressIn_EAST[11] n647 destinationAddressIn_WEST[11]
+ n614 AOI22X1TS
XU1292 n777 destinationAddressIn_NORTH[11] n693 destinationAddressIn_SOUTH[11]
+ n545 AOI22X1TS
XU1294 n774 destinationAddressbuffer[2][11] n721
+ destinationAddressbuffer[0][11] n695 AOI22X1TS
XU1295 n773 destinationAddressbuffer[6][11] n722
+ destinationAddressbuffer[4][11] n696 AOI22X1TS
XU1296 n772 destinationAddressbuffer[3][11] n723
+ destinationAddressbuffer[1][11] n697 AOI22X1TS
XU1297 n771 destinationAddressbuffer[7][11] n840
+ destinationAddressbuffer[5][11] n863 AOI22X1TS
XU1298 n775 n774 n773 n772 n771 NAND4XLTS
XU1299 n776 destinationAddressOut[11] FE_DBTN4_n676 n770 n775 AOI22X1TS
XU1304 n788 dataIn_NORTH[0] n693 dataIn_EAST[0] n647 AOI22X1TS
XU1307 n787 dataIn_SOUTH[0] n545 dataIn_WEST[0] n614 AOI22X1TS
XU1308 n783 dataoutbuffer[0][0] n695 dataoutbuffer[2][0] n721 AOI22X1TS
XU1309 n782 dataoutbuffer[4][0] n696 dataoutbuffer[6][0] n722 AOI22X1TS
XU1310 n781 dataoutbuffer[1][0] n697 dataoutbuffer[3][0] n723 AOI22X1TS
XU1311 n780 dataoutbuffer[5][0] n863 dataoutbuffer[7][0] n840 AOI22X1TS
XU1312 n784 n783 n782 n781 n780 NAND4XLTS
XU1313 n786 dataOut[0] FE_DBTN4_n676 n770 n784 AOI22X1TS
XU1316 n785 cacheDataOut[0] FE_DBTN0_n562 NAND2X1TS
XU1320 n808 dataIn_NORTH[1] n693 dataIn_EAST[1] n647 AOI22X1TS
XU1323 n807 dataIn_SOUTH[1] n545 dataIn_WEST[1] n614 AOI22X1TS
XU1324 n803 dataoutbuffer[0][1] n695 dataoutbuffer[2][1] n721 AOI22X1TS
XU1325 n802 dataoutbuffer[4][1] n696 dataoutbuffer[6][1] n722 AOI22X1TS
XU1326 n801 dataoutbuffer[1][1] n697 dataoutbuffer[3][1] n723 AOI22X1TS
XU1327 n800 dataoutbuffer[5][1] n863 dataoutbuffer[7][1] n840 AOI22X1TS
XU1328 n804 n803 n802 n801 n800 NAND4XLTS
XU1329 n806 dataOut[1] FE_DBTN4_n676 n770 n804 AOI22X1TS
XU1332 n805 cacheDataOut[1] FE_DBTN0_n562 NAND2X1TS
XU1337 n827 dataIn_NORTH[2] n693 dataIn_EAST[2] n647 AOI22X1TS
XU1341 n826 dataIn_SOUTH[2] n545 dataIn_WEST[2] n614 AOI22X1TS
XU1344 n821 dataoutbuffer[0][2] n695 dataoutbuffer[2][2] n721 AOI22X1TS
XU1347 n820 dataoutbuffer[4][2] n696 dataoutbuffer[6][2] n722 AOI22X1TS
XU1350 n819 dataoutbuffer[1][2] n697 dataoutbuffer[3][2] n723 AOI22X1TS
XU1351 n818 dataoutbuffer[5][2] n863 dataoutbuffer[7][2] n840 AOI22X1TS
XU1352 n822 n821 n820 n819 n818 NAND4XLTS
XU1353 n825 dataOut[2] FE_DBTN4_n676 n770 n822 AOI22X1TS
XU1355 n824 cacheDataOut[2] FE_DBTN0_n562 NAND2X1TS
XU1359 n839 dataIn_NORTH[3] n693 dataIn_EAST[3] n647 AOI22X1TS
XU1362 n838 dataIn_SOUTH[3] n545 dataIn_WEST[3] n614 AOI22X1TS
XU1363 n833 dataoutbuffer[0][3] n695 dataoutbuffer[2][3] n721 AOI22X1TS
XU1364 n832 dataoutbuffer[4][3] n696 dataoutbuffer[6][3] n722 AOI22X1TS
XU1365 n831 dataoutbuffer[1][3] n697 dataoutbuffer[3][3] n723 AOI22X1TS
XU1366 n830 dataoutbuffer[5][3] n863 dataoutbuffer[7][3] n840 AOI22X1TS
XU1367 n834 n833 n832 n831 n830 NAND4XLTS
XU1368 n837 dataOut[3] FE_DBTN4_n676 n1942 n834 AOI22X1TS
XU1370 n836 cacheDataOut[3] FE_DBTN0_n562 NAND2X1TS
XU1374 n851 dataIn_NORTH[4] n693 dataIn_EAST[4] n647 AOI22X1TS
XU1377 n850 dataIn_SOUTH[4] n545 dataIn_WEST[4] n614 AOI22X1TS
XU1378 n844 dataoutbuffer[0][4] n695 dataoutbuffer[2][4] n721 AOI22X1TS
XU1379 n843 dataoutbuffer[4][4] n696 dataoutbuffer[6][4] n722 AOI22X1TS
XU1380 n842 dataoutbuffer[1][4] n697 dataoutbuffer[3][4] n723 AOI22X1TS
XU1381 n841 dataoutbuffer[5][4] n863 dataoutbuffer[7][4] n840 AOI22X1TS
XU1382 n845 n844 n843 n842 n841 NAND4XLTS
XU1383 n849 dataOut[4] FE_DBTN4_n676 n1942 n845 AOI22X1TS
XU1385 n848 cacheDataOut[4] FE_DBTN0_n562 NAND2X1TS
XU1389 n875 dataIn_NORTH[5] n693 dataIn_EAST[5] n647 AOI22X1TS
XU1392 n874 dataIn_SOUTH[5] n545 dataIn_WEST[5] n614 AOI22X1TS
XU1393 n867 dataoutbuffer[0][5] n695 dataoutbuffer[2][5] n721 AOI22X1TS
XU1394 n866 dataoutbuffer[4][5] n696 dataoutbuffer[6][5] n722 AOI22X1TS
XU1395 n865 dataoutbuffer[1][5] n697 dataoutbuffer[3][5] n723 AOI22X1TS
XU1396 n864 dataoutbuffer[5][5] n863 dataoutbuffer[7][5] n840 AOI22X1TS
XU1397 n868 n867 n866 n865 n864 NAND4XLTS
XU1398 n873 dataOut[5] FE_DBTN4_n676 n770 n868 AOI22X1TS
XU1400 n872 cacheDataOut[5] FE_DBTN0_n562 NAND2X1TS
XU1403 n881 readRequesterAddress[0] n35 FE_DBTN27_n1536
+ requesterAddressbuffer[7][0] AOI22X1TS
XU1407 n880 FE_DBTN28_n52 requesterAddressIn_WEST[0] n33
+ requesterAddressIn_EAST[0] AOI22X1TS
XU1412 n879 n54 requesterAddressIn_SOUTH[0] FE_DBTN26_n66
+ requesterAddressIn_NORTH[0] AOI22X1TS
XU1414 n884 n35 readRequesterAddress[1] FE_DBTN27_n1536
+ requesterAddressbuffer[7][1] AOI22X1TS
XU1417 n883 FE_DBTN28_n52 requesterAddressIn_WEST[1] n33
+ requesterAddressIn_EAST[1] AOI22X1TS
XU1420 n882 n54 requesterAddressIn_SOUTH[1] FE_DBTN26_n66
+ requesterAddressIn_NORTH[1] AOI22X1TS
XU1423 n888 n35 readRequesterAddress[2] FE_DBTN27_n1536
+ requesterAddressbuffer[7][2] AOI22X1TS
XU1425 n887 FE_DBTN28_n52 requesterAddressIn_WEST[2] n33
+ requesterAddressIn_EAST[2] AOI22X1TS
XU1428 n886 n54 requesterAddressIn_SOUTH[2] FE_DBTN26_n66
+ requesterAddressIn_NORTH[2] AOI22X1TS
XU1429 n893 n35 readRequesterAddress[3] FE_DBTN27_n1536
+ requesterAddressbuffer[7][3] AOI22X1TS
XU1431 n892 FE_DBTN28_n52 requesterAddressIn_WEST[3] n33
+ requesterAddressIn_EAST[3] AOI22X1TS
XU1434 n891 n54 requesterAddressIn_SOUTH[3] FE_DBTN26_n66
+ requesterAddressIn_NORTH[3] AOI22X1TS
XU1437 n896 readRequesterAddress[0] n86 FE_DBTN23_n1484
+ requesterAddressbuffer[6][0] AOI22X1TS
XU1439 n895 requesterAddressIn_WEST[0] FE_DBTN24_n100
+ requesterAddressIn_EAST[0] n84 AOI22X1TS
XU1440 n894 requesterAddressIn_SOUTH[0] n91 requesterAddressIn_NORTH[0]
+ FE_DBTN38_n3 AOI22X1TS
XU1442 n901 readRequesterAddress[1] n86 FE_DBTN23_n1484
+ requesterAddressbuffer[6][1] AOI22X1TS
XU1444 n900 requesterAddressIn_WEST[1] FE_DBTN24_n100
+ requesterAddressIn_EAST[1] n84 AOI22X1TS
XU1446 n899 requesterAddressIn_SOUTH[1] n91 requesterAddressIn_NORTH[1]
+ FE_DBTN38_n3 AOI22X1TS
XU1450 n904 readRequesterAddress[2] n86 FE_DBTN23_n1484
+ requesterAddressbuffer[6][2] AOI22X1TS
XU1451 n903 requesterAddressIn_WEST[2] FE_DBTN24_n100
+ requesterAddressIn_EAST[2] n84 AOI22X1TS
XU1452 n902 requesterAddressIn_SOUTH[2] n91 requesterAddressIn_NORTH[2]
+ FE_DBTN38_n3 AOI22X1TS
XU1454 n910 readRequesterAddress[3] n86 FE_DBTN23_n1484
+ requesterAddressbuffer[6][3] AOI22X1TS
XU1456 n909 requesterAddressIn_WEST[3] FE_DBTN24_n100
+ requesterAddressIn_EAST[3] n84 AOI22X1TS
XU1458 n908 requesterAddressIn_SOUTH[3] n91 requesterAddressIn_NORTH[3]
+ FE_DBTN38_n3 AOI22X1TS
XU1460 n913 readRequesterAddress[0] FE_DBTN30_n12 FE_DBTN16_n1450
+ requesterAddressbuffer[5][0] AOI22X1TS
XU1462 n912 requesterAddressIn_WEST[0] FE_DBTN18_n241
+ requesterAddressIn_EAST[0] n223 AOI22X1TS
XU1464 n911 requesterAddressIn_SOUTH[0] FE_DBTN17_n253
+ requesterAddressIn_NORTH[0] FE_DBTN39_n2 AOI22X1TS
XU1465 n917 readRequesterAddress[1] FE_DBTN30_n12 FE_DBTN16_n1450
+ requesterAddressbuffer[5][1] AOI22X1TS
XU1467 n916 requesterAddressIn_WEST[1] FE_DBTN18_n241
+ requesterAddressIn_EAST[1] n223 AOI22X1TS
XU1468 n915 requesterAddressIn_SOUTH[1] FE_DBTN17_n253
+ requesterAddressIn_NORTH[1] FE_DBTN39_n2 AOI22X1TS
XU1471 n920 readRequesterAddress[2] FE_DBTN30_n12 FE_DBTN16_n1450
+ requesterAddressbuffer[5][2] AOI22X1TS
XU1472 n919 requesterAddressIn_WEST[2] FE_DBTN18_n241
+ requesterAddressIn_EAST[2] n223 AOI22X1TS
XU1473 n918 requesterAddressIn_SOUTH[2] FE_DBTN17_n253
+ requesterAddressIn_NORTH[2] FE_DBTN39_n2 AOI22X1TS
XU1475 n927 readRequesterAddress[3] FE_DBTN30_n12 FE_DBTN16_n1450
+ requesterAddressbuffer[5][3] AOI22X1TS
XU1477 n926 requesterAddressIn_WEST[3] FE_DBTN18_n241
+ requesterAddressIn_EAST[3] n223 AOI22X1TS
XU1480 n925 requesterAddressIn_SOUTH[3] FE_DBTN17_n253
+ requesterAddressIn_NORTH[3] FE_DBTN39_n2 AOI22X1TS
XU1482 n935 readRequesterAddress[0] n274 FE_DBTN13_n1419
+ requesterAddressbuffer[4][0] AOI22X1TS
XU1484 n934 requesterAddressIn_WEST[0] FE_DBTN14_n289
+ requesterAddressIn_EAST[0] n273 AOI22X1TS
XU1485 n933 requesterAddressIn_SOUTH[0] FE_DBTN33_n9
+ requesterAddressIn_NORTH[0] FE_DBTN31_n11 AOI22X1TS
XU1487 n942 readRequesterAddress[1] n274 FE_DBTN13_n1419
+ requesterAddressbuffer[4][1] AOI22X1TS
XU1489 n941 requesterAddressIn_WEST[1] FE_DBTN14_n289
+ requesterAddressIn_EAST[1] n273 AOI22X1TS
XU1490 n940 requesterAddressIn_SOUTH[1] FE_DBTN33_n9
+ requesterAddressIn_NORTH[1] FE_DBTN31_n11 AOI22X1TS
XU1494 n948 readRequesterAddress[2] n274 FE_DBTN13_n1419
+ requesterAddressbuffer[4][2] AOI22X1TS
XU1495 n947 requesterAddressIn_WEST[2] FE_DBTN14_n289
+ requesterAddressIn_EAST[2] n273 AOI22X1TS
XU1496 n946 requesterAddressIn_SOUTH[2] FE_DBTN33_n9
+ requesterAddressIn_NORTH[2] FE_DBTN31_n11 AOI22X1TS
XU1499 n956 readRequesterAddress[3] n274 FE_DBTN13_n1419
+ requesterAddressbuffer[4][3] AOI22X1TS
XU1501 n955 requesterAddressIn_WEST[3] FE_DBTN14_n289
+ requesterAddressIn_EAST[3] n273 AOI22X1TS
XU1502 n954 requesterAddressIn_SOUTH[3] FE_DBTN33_n9
+ requesterAddressIn_NORTH[3] FE_DBTN31_n11 AOI22X1TS
XU1505 n963 readRequesterAddress[0] n133 FE_DBTN22_n1390
+ requesterAddressbuffer[3][0] AOI22X1TS
XU1507 n962 requesterAddressIn_WEST[0] n137 requesterAddressIn_EAST[0] n146
+ AOI22X1TS
XU1510 n961 requesterAddressIn_SOUTH[0] n132 requesterAddressIn_NORTH[0] n147
+ AOI22X1TS
XU1512 n971 readRequesterAddress[1] n133 FE_DBTN22_n1390
+ requesterAddressbuffer[3][1] AOI22X1TS
XU1514 n970 requesterAddressIn_WEST[1] n137 requesterAddressIn_EAST[1] n146
+ AOI22X1TS
XU1515 n969 requesterAddressIn_SOUTH[1] n132 requesterAddressIn_NORTH[1] n147
+ AOI22X1TS
XU1519 n979 readRequesterAddress[2] n133 FE_DBTN22_n1390
+ requesterAddressbuffer[3][2] AOI22X1TS
XU1520 n978 requesterAddressIn_WEST[2] n137 requesterAddressIn_EAST[2] n146
+ AOI22X1TS
XU1522 n977 requesterAddressIn_SOUTH[2] n132 requesterAddressIn_NORTH[2] n147
+ AOI22X1TS
XU1524 n985 readRequesterAddress[3] n133 FE_DBTN22_n1390
+ requesterAddressbuffer[3][3] AOI22X1TS
XU1525 n984 requesterAddressIn_WEST[3] n137 requesterAddressIn_EAST[3] n146
+ AOI22X1TS
XU1526 n983 requesterAddressIn_SOUTH[3] n132 requesterAddressIn_NORTH[3] n147
+ AOI22X1TS
XU1528 n988 readRequesterAddress[0] FE_DBTN32_n10 FE_DBTN20_n1356
+ requesterAddressbuffer[2][0] AOI22X1TS
XU1530 n987 requesterAddressIn_WEST[0] FE_DBTN21_n198
+ requesterAddressIn_EAST[0] n183 AOI22X1TS
XU1531 n986 requesterAddressIn_SOUTH[0] FE_DBTN37_n4
+ requesterAddressIn_NORTH[0] n191 AOI22X1TS
XU1532 n993 readRequesterAddress[1] FE_DBTN32_n10 FE_DBTN20_n1356
+ requesterAddressbuffer[2][1] AOI22X1TS
XU1534 n992 requesterAddressIn_WEST[1] FE_DBTN21_n198
+ requesterAddressIn_EAST[1] n183 AOI22X1TS
XU1537 n991 requesterAddressIn_SOUTH[1] FE_DBTN37_n4
+ requesterAddressIn_NORTH[1] n191 AOI22X1TS
XU1540 n997 readRequesterAddress[2] FE_DBTN32_n10 FE_DBTN20_n1356
+ requesterAddressbuffer[2][2] AOI22X1TS
XU1541 n996 requesterAddressIn_WEST[2] FE_DBTN21_n198
+ requesterAddressIn_EAST[2] n183 AOI22X1TS
XU1542 n995 requesterAddressIn_SOUTH[2] FE_DBTN37_n4
+ requesterAddressIn_NORTH[2] n191 AOI22X1TS
XU1544 n1002 readRequesterAddress[3] FE_DBTN32_n10 FE_DBTN20_n1356
+ requesterAddressbuffer[2][3] AOI22X1TS
XU1546 n1001 requesterAddressIn_WEST[3] FE_DBTN21_n198
+ requesterAddressIn_EAST[3] n183 AOI22X1TS
XU1547 n1000 requesterAddressIn_SOUTH[3] FE_DBTN37_n4
+ requesterAddressIn_NORTH[3] n191 AOI22X1TS
XU1549 n1009 readRequesterAddress[0] n317 FE_DBTN10_n356
+ requesterAddressbuffer[1][0] AOI22X1TS
XU1551 n1008 requesterAddressIn_WEST[0] FE_DBTN11_n343
+ requesterAddressIn_EAST[0] n315 AOI22X1TS
XU1552 n1007 requesterAddressIn_SOUTH[0] n324 requesterAddressIn_NORTH[0] n338
+ AOI22X1TS
XU1553 n1016 readRequesterAddress[1] n317 FE_DBTN10_n356
+ requesterAddressbuffer[1][1] AOI22X1TS
XU1555 n1015 requesterAddressIn_WEST[1] FE_DBTN11_n343
+ requesterAddressIn_EAST[1] n315 AOI22X1TS
XU1557 n1014 requesterAddressIn_SOUTH[1] n324 requesterAddressIn_NORTH[1] n338
+ AOI22X1TS
XU1560 n1024 readRequesterAddress[2] n317 FE_DBTN10_n356
+ requesterAddressbuffer[1][2] AOI22X1TS
XU1561 n1023 requesterAddressIn_WEST[2] FE_DBTN11_n343
+ requesterAddressIn_EAST[2] n315 AOI22X1TS
XU1562 n1022 requesterAddressIn_SOUTH[2] n324 requesterAddressIn_NORTH[2] n338
+ AOI22X1TS
XU1564 n1033 readRequesterAddress[3] n317 FE_DBTN10_n356
+ requesterAddressbuffer[1][3] AOI22X1TS
XU1566 n1032 requesterAddressIn_WEST[3] FE_DBTN11_n343
+ requesterAddressIn_EAST[3] n315 AOI22X1TS
XU1568 n1031 requesterAddressIn_SOUTH[3] n324 requesterAddressIn_NORTH[3] n338
+ AOI22X1TS
XU1570 n1039 readRequesterAddress[0] FE_DBTN29_n13 FE_DBTN6_n425
+ requesterAddressbuffer[0][0] AOI22X1TS
XU1572 n1038 requesterAddressIn_WEST[0] FE_DBTN7_n415
+ requesterAddressIn_EAST[0] FE_DBTN40_n1 AOI22X1TS
XU1574 n1037 requesterAddressIn_SOUTH[0] FE_DBTN35_n6
+ requesterAddressIn_NORTH[0] FE_DBTN36_n5 AOI22X1TS
XU1575 n1046 readRequesterAddress[1] FE_DBTN29_n13 FE_DBTN6_n425
+ requesterAddressbuffer[0][1] AOI22X1TS
XU1577 n1045 requesterAddressIn_WEST[1] FE_DBTN7_n415
+ requesterAddressIn_EAST[1] FE_DBTN40_n1 AOI22X1TS
XU1578 n1044 requesterAddressIn_SOUTH[1] FE_DBTN35_n6
+ requesterAddressIn_NORTH[1] FE_DBTN36_n5 AOI22X1TS
XU1581 n1051 readRequesterAddress[2] FE_DBTN29_n13 FE_DBTN6_n425
+ requesterAddressbuffer[0][2] AOI22X1TS
XU1582 n1050 requesterAddressIn_WEST[2] FE_DBTN7_n415
+ requesterAddressIn_EAST[2] FE_DBTN40_n1 AOI22X1TS
XU1583 n1049 requesterAddressIn_SOUTH[2] FE_DBTN35_n6
+ requesterAddressIn_NORTH[2] FE_DBTN36_n5 AOI22X1TS
XU1585 n1058 readRequesterAddress[3] FE_DBTN29_n13 FE_DBTN6_n425
+ requesterAddressbuffer[0][3] AOI22X1TS
XU1587 n1057 requesterAddressIn_WEST[3] FE_DBTN7_n415
+ requesterAddressIn_EAST[3] FE_DBTN40_n1 AOI22X1TS
XU1588 n1056 requesterAddressIn_SOUTH[3] FE_DBTN35_n6
+ requesterAddressIn_NORTH[3] FE_DBTN36_n5 AOI22X1TS
XU1590 n1062 FE_DBTN29_n13 cacheDataOut[0] FE_DBTN6_n425 dataoutbuffer[0][0]
+ AOI22X1TS
XU1591 n1061 FE_DBTN7_n415 dataIn_WEST[0] FE_DBTN40_n1 dataIn_EAST[0] AOI22X1TS
XU1594 n1060 FE_DBTN35_n6 dataIn_SOUTH[0] FE_DBTN36_n5 dataIn_NORTH[0]
+ AOI22X1TS
XU1596 n1068 FE_DBTN29_n13 cacheDataOut[1] FE_DBTN6_n425 dataoutbuffer[0][1]
+ AOI22X1TS
XU1597 n1067 FE_DBTN7_n415 dataIn_WEST[1] FE_DBTN40_n1 dataIn_EAST[1] AOI22X1TS
XU1600 n1066 FE_DBTN35_n6 dataIn_SOUTH[1] FE_DBTN36_n5 dataIn_NORTH[1]
+ AOI22X1TS
XU1604 n1073 FE_DBTN29_n13 cacheDataOut[2] FE_DBTN6_n425 dataoutbuffer[0][2]
+ AOI22X1TS
XU1605 n1072 FE_DBTN7_n415 dataIn_WEST[2] FE_DBTN40_n1 dataIn_EAST[2] AOI22X1TS
XU1607 n1071 FE_DBTN35_n6 dataIn_SOUTH[2] FE_DBTN36_n5 dataIn_NORTH[2]
+ AOI22X1TS
XU1609 n1076 FE_DBTN29_n13 cacheDataOut[3] FE_DBTN6_n425 dataoutbuffer[0][3]
+ AOI22X1TS
XU1610 n1075 FE_DBTN7_n415 dataIn_WEST[3] FE_DBTN40_n1 dataIn_EAST[3] AOI22X1TS
XU1612 n1074 FE_DBTN35_n6 dataIn_SOUTH[3] FE_DBTN36_n5 dataIn_NORTH[3]
+ AOI22X1TS
XU1614 n1079 FE_DBTN29_n13 cacheDataOut[4] FE_DBTN6_n425 dataoutbuffer[0][4]
+ AOI22X1TS
XU1615 n1078 FE_DBTN7_n415 dataIn_WEST[4] FE_DBTN40_n1 dataIn_EAST[4] AOI22X1TS
XU1617 n1077 FE_DBTN35_n6 dataIn_SOUTH[4] FE_DBTN36_n5 dataIn_NORTH[4]
+ AOI22X1TS
XU1619 n1083 FE_DBTN29_n13 cacheDataOut[5] FE_DBTN6_n425 dataoutbuffer[0][5]
+ AOI22X1TS
XU1620 n1082 FE_DBTN7_n415 dataIn_WEST[5] FE_DBTN40_n1 dataIn_EAST[5] AOI22X1TS
XU1622 n1081 FE_DBTN35_n6 dataIn_SOUTH[5] FE_DBTN36_n5 dataIn_NORTH[5]
+ AOI22X1TS
XU1624 n1088 n317 cacheDataOut[0] FE_DBTN10_n356 dataoutbuffer[1][0] AOI22X1TS
XU1625 n1087 FE_DBTN11_n343 dataIn_WEST[0] n315 dataIn_EAST[0] AOI22X1TS
XU1629 n1086 n338 dataIn_NORTH[0] n324 dataIn_SOUTH[0] AOI22X1TS
XU1631 n1095 n317 cacheDataOut[1] FE_DBTN10_n356 dataoutbuffer[1][1] AOI22X1TS
XU1632 n1094 FE_DBTN11_n343 dataIn_WEST[1] n315 dataIn_EAST[1] AOI22X1TS
XU1637 n1093 n338 dataIn_NORTH[1] n324 dataIn_SOUTH[1] AOI22X1TS
XU1640 n1104 n317 cacheDataOut[2] FE_DBTN10_n356 dataoutbuffer[1][2] AOI22X1TS
XU1641 n1103 FE_DBTN11_n343 dataIn_WEST[2] n315 dataIn_EAST[2] AOI22X1TS
XU1645 n1102 n338 dataIn_NORTH[2] n324 dataIn_SOUTH[2] AOI22X1TS
XU1647 n1110 n317 cacheDataOut[3] FE_DBTN10_n356 dataoutbuffer[1][3] AOI22X1TS
XU1648 n1109 FE_DBTN11_n343 dataIn_WEST[3] n315 dataIn_EAST[3] AOI22X1TS
XU1652 n1108 n338 dataIn_NORTH[3] n324 dataIn_SOUTH[3] AOI22X1TS
XU1654 n1339 n317 cacheDataOut[4] FE_DBTN10_n356 dataoutbuffer[1][4] AOI22X1TS
XU1655 n1338 FE_DBTN11_n343 dataIn_WEST[4] n315 dataIn_EAST[4] AOI22X1TS
XU1659 n1337 n338 dataIn_NORTH[4] n324 dataIn_SOUTH[4] AOI22X1TS
XU1661 n1345 n317 cacheDataOut[5] FE_DBTN10_n356 dataoutbuffer[1][5] AOI22X1TS
XU1662 n1344 FE_DBTN11_n343 dataIn_WEST[5] n315 dataIn_EAST[5] AOI22X1TS
XU1666 n1343 n338 dataIn_NORTH[5] n324 dataIn_SOUTH[5] AOI22X1TS
XU1667 n1349 FE_DBTN32_n10 cacheDataOut[0] FE_DBTN20_n1356 dataoutbuffer[2][0]
+ AOI22X1TS
XU1668 n1348 FE_DBTN21_n198 dataIn_WEST[0] n183 dataIn_EAST[0] AOI22X1TS
XU1669 n1347 n191 dataIn_NORTH[0] FE_DBTN37_n4 dataIn_SOUTH[0] AOI22X1TS
XU1670 n1355 FE_DBTN32_n10 cacheDataOut[1] FE_DBTN20_n1356 dataoutbuffer[2][1]
+ AOI22X1TS
XU1671 n1354 FE_DBTN21_n198 dataIn_WEST[1] n183 dataIn_EAST[1] AOI22X1TS
XU1673 n1353 n191 dataIn_NORTH[1] FE_DBTN37_n4 dataIn_SOUTH[1] AOI22X1TS
XU1676 n1363 FE_DBTN32_n10 cacheDataOut[2] FE_DBTN20_n1356 dataoutbuffer[2][2]
+ AOI22X1TS
XU1677 n1362 FE_DBTN21_n198 dataIn_WEST[2] n183 dataIn_EAST[2] AOI22X1TS
XU1678 n1361 n191 dataIn_NORTH[2] FE_DBTN37_n4 dataIn_SOUTH[2] AOI22X1TS
XU1679 n1368 FE_DBTN32_n10 cacheDataOut[3] FE_DBTN20_n1356 dataoutbuffer[2][3]
+ AOI22X1TS
XU1680 n1367 FE_DBTN21_n198 dataIn_WEST[3] n183 dataIn_EAST[3] AOI22X1TS
XU1681 n1366 n191 dataIn_NORTH[3] FE_DBTN37_n4 dataIn_SOUTH[3] AOI22X1TS
XU1682 n1372 FE_DBTN32_n10 cacheDataOut[4] FE_DBTN20_n1356 dataoutbuffer[2][4]
+ AOI22X1TS
XU1683 n1371 FE_DBTN21_n198 dataIn_WEST[4] n183 dataIn_EAST[4] AOI22X1TS
XU1684 n1370 n191 dataIn_NORTH[4] FE_DBTN37_n4 dataIn_SOUTH[4] AOI22X1TS
XU1685 n1378 FE_DBTN32_n10 cacheDataOut[5] FE_DBTN20_n1356 dataoutbuffer[2][5]
+ AOI22X1TS
XU1686 n1377 FE_DBTN21_n198 dataIn_WEST[5] n183 dataIn_EAST[5] AOI22X1TS
XU1687 n1376 n191 dataIn_NORTH[5] FE_DBTN37_n4 dataIn_SOUTH[5] AOI22X1TS
XU1688 n1382 n133 cacheDataOut[0] FE_DBTN22_n1390 dataoutbuffer[3][0] AOI22X1TS
XU1689 n1381 n137 dataIn_WEST[0] n146 dataIn_EAST[0] AOI22X1TS
XU1690 n1380 n147 dataIn_NORTH[0] n132 dataIn_SOUTH[0] AOI22X1TS
XU1691 n1388 n133 cacheDataOut[1] FE_DBTN22_n1390 dataoutbuffer[3][1] AOI22X1TS
XU1692 n1387 n137 dataIn_WEST[1] n146 dataIn_EAST[1] AOI22X1TS
XU1694 n1386 n147 dataIn_NORTH[1] n132 dataIn_SOUTH[1] AOI22X1TS
XU1697 n1394 n133 cacheDataOut[2] FE_DBTN22_n1390 dataoutbuffer[3][2] AOI22X1TS
XU1698 n1393 n137 dataIn_WEST[2] n146 dataIn_EAST[2] AOI22X1TS
XU1699 n1392 n147 dataIn_NORTH[2] n132 dataIn_SOUTH[2] AOI22X1TS
XU1700 n1397 n133 cacheDataOut[3] FE_DBTN22_n1390 dataoutbuffer[3][3] AOI22X1TS
XU1701 n1396 n137 dataIn_WEST[3] n146 dataIn_EAST[3] AOI22X1TS
XU1702 n1395 n147 dataIn_NORTH[3] n132 dataIn_SOUTH[3] AOI22X1TS
XU1703 n1402 n133 cacheDataOut[4] FE_DBTN22_n1390 dataoutbuffer[3][4] AOI22X1TS
XU1704 n1401 n137 dataIn_WEST[4] n146 dataIn_EAST[4] AOI22X1TS
XU1705 n1400 n147 dataIn_NORTH[4] n132 dataIn_SOUTH[4] AOI22X1TS
XU1706 n1407 n133 cacheDataOut[5] FE_DBTN22_n1390 dataoutbuffer[3][5] AOI22X1TS
XU1707 n1406 n137 dataIn_WEST[5] n146 dataIn_EAST[5] AOI22X1TS
XU1708 n1405 n147 dataIn_NORTH[5] n132 dataIn_SOUTH[5] AOI22X1TS
XU1709 n1412 n274 cacheDataOut[0] FE_DBTN13_n1419 dataoutbuffer[4][0] AOI22X1TS
XU1710 n1411 FE_DBTN14_n289 dataIn_WEST[0] n273 dataIn_EAST[0] AOI22X1TS
XU1711 n1410 FE_DBTN33_n9 dataIn_SOUTH[0] FE_DBTN31_n11 dataIn_NORTH[0]
+ AOI22X1TS
XU1712 n1417 n274 cacheDataOut[1] FE_DBTN13_n1419 dataoutbuffer[4][1] AOI22X1TS
XU1713 n1416 FE_DBTN14_n289 dataIn_WEST[1] n273 dataIn_EAST[1] AOI22X1TS
XU1714 n1415 FE_DBTN33_n9 dataIn_SOUTH[1] FE_DBTN31_n11 dataIn_NORTH[1]
+ AOI22X1TS
XU1716 n1426 n274 cacheDataOut[2] FE_DBTN13_n1419 dataoutbuffer[4][2] AOI22X1TS
XU1717 n1425 FE_DBTN14_n289 dataIn_WEST[2] n273 dataIn_EAST[2] AOI22X1TS
XU1718 n1424 FE_DBTN33_n9 dataIn_SOUTH[2] FE_DBTN31_n11 dataIn_NORTH[2]
+ AOI22X1TS
XU1719 n1430 n274 cacheDataOut[3] FE_DBTN13_n1419 dataoutbuffer[4][3] AOI22X1TS
XU1720 n1429 FE_DBTN14_n289 dataIn_WEST[3] n273 dataIn_EAST[3] AOI22X1TS
XU1721 n1428 FE_DBTN33_n9 dataIn_SOUTH[3] FE_DBTN31_n11 dataIn_NORTH[3]
+ AOI22X1TS
XU1722 n1434 n274 cacheDataOut[4] FE_DBTN13_n1419 dataoutbuffer[4][4] AOI22X1TS
XU1723 n1433 FE_DBTN14_n289 dataIn_WEST[4] n273 dataIn_EAST[4] AOI22X1TS
XU1724 n1432 FE_DBTN33_n9 dataIn_SOUTH[4] FE_DBTN31_n11 dataIn_NORTH[4]
+ AOI22X1TS
XU1725 n1440 n274 cacheDataOut[5] FE_DBTN13_n1419 dataoutbuffer[4][5] AOI22X1TS
XU1726 n1439 FE_DBTN14_n289 dataIn_WEST[5] n273 dataIn_EAST[5] AOI22X1TS
XU1727 n1438 FE_DBTN33_n9 dataIn_SOUTH[5] FE_DBTN31_n11 dataIn_NORTH[5]
+ AOI22X1TS
XU1728 n1444 FE_DBTN30_n12 cacheDataOut[0] FE_DBTN16_n1450 dataoutbuffer[5][0]
+ AOI22X1TS
XU1729 n1443 FE_DBTN18_n241 dataIn_WEST[0] n223 dataIn_EAST[0] AOI22X1TS
XU1730 n1442 FE_DBTN39_n2 dataIn_NORTH[0] FE_DBTN17_n253 dataIn_SOUTH[0]
+ AOI22X1TS
XU1731 n1449 FE_DBTN30_n12 cacheDataOut[1] FE_DBTN16_n1450 dataoutbuffer[5][1]
+ AOI22X1TS
XU1732 n1448 FE_DBTN18_n241 dataIn_WEST[1] n223 dataIn_EAST[1] AOI22X1TS
XU1733 n1447 FE_DBTN39_n2 dataIn_NORTH[1] FE_DBTN17_n253 dataIn_SOUTH[1]
+ AOI22X1TS
XU1736 n1454 FE_DBTN30_n12 cacheDataOut[2] FE_DBTN16_n1450 dataoutbuffer[5][2]
+ AOI22X1TS
XU1737 n1453 FE_DBTN18_n241 dataIn_WEST[2] n223 dataIn_EAST[2] AOI22X1TS
XU1738 n1452 FE_DBTN39_n2 dataIn_NORTH[2] FE_DBTN17_n253 dataIn_SOUTH[2]
+ AOI22X1TS
XU1739 n1458 FE_DBTN30_n12 cacheDataOut[3] FE_DBTN16_n1450 dataoutbuffer[5][3]
+ AOI22X1TS
XU1740 n1457 FE_DBTN18_n241 dataIn_WEST[3] n223 dataIn_EAST[3] AOI22X1TS
XU1741 n1456 FE_DBTN39_n2 dataIn_NORTH[3] FE_DBTN17_n253 dataIn_SOUTH[3]
+ AOI22X1TS
XU1742 n1461 FE_DBTN30_n12 cacheDataOut[4] FE_DBTN16_n1450 dataoutbuffer[5][4]
+ AOI22X1TS
XU1743 n1460 FE_DBTN18_n241 dataIn_WEST[4] n223 dataIn_EAST[4] AOI22X1TS
XU1744 n1459 FE_DBTN39_n2 dataIn_NORTH[4] FE_DBTN17_n253 dataIn_SOUTH[4]
+ AOI22X1TS
XU1745 n1466 FE_DBTN30_n12 cacheDataOut[5] FE_DBTN16_n1450 dataoutbuffer[5][5]
+ AOI22X1TS
XU1746 n1465 FE_DBTN18_n241 dataIn_WEST[5] n223 dataIn_EAST[5] AOI22X1TS
XU1747 n1464 FE_DBTN39_n2 dataIn_NORTH[5] FE_DBTN17_n253 dataIn_SOUTH[5]
+ AOI22X1TS
XU1748 n1474 n86 cacheDataOut[0] FE_DBTN23_n1484 dataoutbuffer[6][0] AOI22X1TS
XU1749 n1473 FE_DBTN24_n100 dataIn_WEST[0] n84 dataIn_EAST[0] AOI22X1TS
XU1750 n1472 FE_DBTN38_n3 dataIn_NORTH[0] n91 dataIn_SOUTH[0] AOI22X1TS
XU1751 n1482 n86 cacheDataOut[1] FE_DBTN23_n1484 dataoutbuffer[6][1] AOI22X1TS
XU1752 n1481 FE_DBTN24_n100 dataIn_WEST[1] n84 dataIn_EAST[1] AOI22X1TS
XU1753 n1480 FE_DBTN38_n3 dataIn_NORTH[1] n91 dataIn_SOUTH[1] AOI22X1TS
XU1756 n1494 n86 cacheDataOut[2] FE_DBTN23_n1484 dataoutbuffer[6][2] AOI22X1TS
XU1757 n1493 FE_DBTN24_n100 dataIn_WEST[2] n84 dataIn_EAST[2] AOI22X1TS
XU1758 n1492 FE_DBTN38_n3 dataIn_NORTH[2] n91 dataIn_SOUTH[2] AOI22X1TS
XU1759 n1502 n86 cacheDataOut[3] FE_DBTN23_n1484 dataoutbuffer[6][3] AOI22X1TS
XU1760 n1501 FE_DBTN24_n100 dataIn_WEST[3] n84 dataIn_EAST[3] AOI22X1TS
XU1761 n1500 FE_DBTN38_n3 dataIn_NORTH[3] n91 dataIn_SOUTH[3] AOI22X1TS
XU1762 n1509 n86 cacheDataOut[4] FE_DBTN23_n1484 dataoutbuffer[6][4] AOI22X1TS
XU1763 n1508 FE_DBTN24_n100 dataIn_WEST[4] n84 dataIn_EAST[4] AOI22X1TS
XU1764 n1507 FE_DBTN38_n3 dataIn_NORTH[4] n91 dataIn_SOUTH[4] AOI22X1TS
XU1765 n1518 n86 cacheDataOut[5] FE_DBTN23_n1484 dataoutbuffer[6][5] AOI22X1TS
XU1766 n1517 FE_DBTN24_n100 dataIn_WEST[5] n84 dataIn_EAST[5] AOI22X1TS
XU1767 n1516 FE_DBTN38_n3 dataIn_NORTH[5] n91 dataIn_SOUTH[5] AOI22X1TS
XU1768 n1527 n35 cacheDataOut[0] FE_DBTN27_n1536 dataoutbuffer[7][0] AOI22X1TS
XU1769 n1526 FE_DBTN28_n52 dataIn_WEST[0] n33 dataIn_EAST[0] AOI22X1TS
XU1770 n1525 n54 dataIn_SOUTH[0] FE_DBTN26_n66 dataIn_NORTH[0] AOI22X1TS
XU1771 n1535 n35 cacheDataOut[1] FE_DBTN27_n1536 dataoutbuffer[7][1] AOI22X1TS
XU1772 n1534 FE_DBTN28_n52 dataIn_WEST[1] n33 dataIn_EAST[1] AOI22X1TS
XU1773 n1533 n54 dataIn_SOUTH[1] FE_DBTN26_n66 dataIn_NORTH[1] AOI22X1TS
XU1775 n1543 n35 cacheDataOut[2] FE_DBTN27_n1536 dataoutbuffer[7][2] AOI22X1TS
XU1776 n1542 FE_DBTN28_n52 dataIn_WEST[2] n33 dataIn_EAST[2] AOI22X1TS
XU1777 n1541 n54 dataIn_SOUTH[2] FE_DBTN26_n66 dataIn_NORTH[2] AOI22X1TS
XU1778 n1551 n35 cacheDataOut[3] FE_DBTN27_n1536 dataoutbuffer[7][3] AOI22X1TS
XU1779 n1550 FE_DBTN28_n52 dataIn_WEST[3] n33 dataIn_EAST[3] AOI22X1TS
XU1780 n1549 n54 dataIn_SOUTH[3] FE_DBTN26_n66 dataIn_NORTH[3] AOI22X1TS
XU1781 n1561 n35 cacheDataOut[4] FE_DBTN27_n1536 dataoutbuffer[7][4] AOI22X1TS
XU1782 n1560 FE_DBTN28_n52 dataIn_WEST[4] n33 dataIn_EAST[4] AOI22X1TS
XU1783 n1559 n54 dataIn_SOUTH[4] FE_DBTN26_n66 dataIn_NORTH[4] AOI22X1TS
XU1784 n1570 n35 cacheDataOut[5] FE_DBTN27_n1536 dataoutbuffer[7][5] AOI22X1TS
XU1785 n1569 FE_DBTN28_n52 dataIn_WEST[5] n33 dataIn_EAST[5] AOI22X1TS
XU1786 n1568 n54 dataIn_SOUTH[5] FE_DBTN26_n66 dataIn_NORTH[5] AOI22X1TS
XU1788 n1575 n1573 readIn_SOUTH readIn_NORTH n1572 AOI22X1TS
XU1789 n1578 n1576 FE_DBTN216_readInBuffer_EAST n1575 n1574 AOI22X1TS
XU1790 n1582 n1579 readIn_WEST n1578 n1577 AOI22X1TS
XU1791 n2083 n1582 n1536 n1580 FE_DBTN27_n1536 n1956 AOI32X1TS
XU1793 n1586 n1584 readIn_SOUTH readIn_NORTH n1583 AOI22X1TS
XU1794 n1589 n1587 FE_DBTN216_readInBuffer_EAST n1586 n1585 AOI22X1TS
XU1795 n1593 n1590 readIn_WEST n1589 n1588 AOI22X1TS
XU1796 n2084 n1593 n1484 n1591 FE_DBTN23_n1484 n1957 AOI32X1TS
XU1797 n1599 n1597 readIn_SOUTH readIn_NORTH n1594 AOI22X1TS
XU1798 n1602 n1600 FE_DBTN216_readInBuffer_EAST n1599 n1598 AOI22X1TS
XU1799 n1606 n1603 readIn_WEST n1602 n1601 AOI22X1TS
XU1800 n2085 n1606 n1450 n1604 FE_DBTN16_n1450 n1958 AOI32X1TS
XU1803 n1610 n1608 readIn_SOUTH readIn_NORTH n1607 AOI22X1TS
XU1804 n1613 n1611 FE_DBTN216_readInBuffer_EAST n1610 n1609 AOI22X1TS
XU1805 n1618 n1615 readIn_WEST n1613 n1612 AOI22X1TS
XU1806 n2086 n1618 n1419 n1616 FE_DBTN13_n1419 n1959 AOI32X1TS
XU1807 n1620 n123 readIn_SOUTH readIn_NORTH n27 AOI22X1TS
XU1808 n1623 n1621 FE_DBTN216_readInBuffer_EAST n1620 n1619 AOI22X1TS
XU1809 n1627 n1624 readIn_WEST n1623 n1622 AOI22X1TS
XU1810 n2087 n1627 n1390 n1625 FE_DBTN22_n1390 n1960 AOI32X1TS
XU1811 n1631 n1629 readIn_SOUTH readIn_NORTH n1628 AOI22X1TS
XU1812 n1635 n1633 FE_DBTN216_readInBuffer_EAST n1631 n1630 AOI22X1TS
XU1813 n1639 n1636 readIn_WEST n1635 n1634 AOI22X1TS
XU1814 n2088 n1639 n1356 n1637 FE_DBTN20_n1356 n1961 AOI32X1TS
XU1815 n1645 n1643 readIn_SOUTH readIn_NORTH n1640 AOI22X1TS
XU1816 n1648 n1646 FE_DBTN216_readInBuffer_EAST n1645 n1644 AOI22X1TS
XU1817 n1652 n1650 readIn_WEST n1648 n1647 AOI22X1TS
XU1818 n2089 n1652 n356 n1651 FE_DBTN10_n356 n1962 AOI32X1TS
XU1819 n1658 n1656 readIn_SOUTH readIn_NORTH n1653 AOI22X1TS
XU1820 n1662 n1660 FE_DBTN216_readInBuffer_EAST n1658 n1657 AOI22X1TS
XU1821 n1665 n1663 readIn_WEST n1662 n1661 AOI22X1TS
XU1822 n2090 n1665 n425 n1664 FE_DBTN6_n425 n1963 AOI32X1TS
XU1823 n1671 readRequesterAddress[0] n35 FE_DBTN27_n1536
+ destinationAddressbuffer[7][0] AOI22X1TS
XU1824 n1670 FE_DBTN28_n52 destinationAddressIn_WEST[0] n33
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1826 n1669 n54 destinationAddressIn_SOUTH[0] FE_DBTN26_n66
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1827 n1678 n35 readRequesterAddress[1] FE_DBTN27_n1536
+ destinationAddressbuffer[7][1] AOI22X1TS
XU1828 n1677 FE_DBTN28_n52 destinationAddressIn_WEST[1] n33
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1830 n1676 n54 destinationAddressIn_SOUTH[1] FE_DBTN26_n66
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1831 n1687 n35 readRequesterAddress[2] FE_DBTN27_n1536
+ destinationAddressbuffer[7][2] AOI22X1TS
XU1832 n1686 FE_DBTN28_n52 destinationAddressIn_WEST[2] n33
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1834 n1685 n54 destinationAddressIn_SOUTH[2] FE_DBTN26_n66
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1835 n1694 n35 readRequesterAddress[3] FE_DBTN27_n1536
+ destinationAddressbuffer[7][3] AOI22X1TS
XU1836 n1693 FE_DBTN28_n52 destinationAddressIn_WEST[3] n33
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1838 n1692 n54 destinationAddressIn_SOUTH[3] FE_DBTN26_n66
+ destinationAddressIn_NORTH[3] AOI22X1TS
XU1839 n1699 readRequesterAddress[0] n86 FE_DBTN23_n1484
+ destinationAddressbuffer[6][0] AOI22X1TS
XU1840 n1698 FE_DBTN24_n100 destinationAddressIn_WEST[0] n84
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1844 n1697 FE_DBTN38_n3 destinationAddressIn_NORTH[0] n91
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1845 n1708 readRequesterAddress[1] n86 FE_DBTN23_n1484
+ destinationAddressbuffer[6][1] AOI22X1TS
XU1846 n1707 FE_DBTN24_n100 destinationAddressIn_WEST[1] n84
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1850 n1706 FE_DBTN38_n3 destinationAddressIn_NORTH[1] n91
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1851 n1716 readRequesterAddress[2] n86 FE_DBTN23_n1484
+ destinationAddressbuffer[6][2] AOI22X1TS
XU1852 n1715 FE_DBTN24_n100 destinationAddressIn_WEST[2] n84
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1856 n1714 FE_DBTN38_n3 destinationAddressIn_NORTH[2] n91
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1857 n1723 readRequesterAddress[3] n86 FE_DBTN23_n1484
+ destinationAddressbuffer[6][3] AOI22X1TS
XU1858 n1722 FE_DBTN24_n100 destinationAddressIn_WEST[3] n84
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1862 n1721 FE_DBTN38_n3 destinationAddressIn_NORTH[3] n91
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1863 n1729 readRequesterAddress[0] FE_DBTN30_n12 FE_DBTN16_n1450
+ destinationAddressbuffer[5][0] AOI22X1TS
XU1864 n1728 FE_DBTN18_n241 destinationAddressIn_WEST[0] n223
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1865 n1727 FE_DBTN39_n2 destinationAddressIn_NORTH[0] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1866 n1738 readRequesterAddress[1] FE_DBTN30_n12 FE_DBTN16_n1450
+ destinationAddressbuffer[5][1] AOI22X1TS
XU1867 n1737 FE_DBTN18_n241 destinationAddressIn_WEST[1] n223
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1868 n1736 FE_DBTN39_n2 destinationAddressIn_NORTH[1] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1869 n1749 readRequesterAddress[2] FE_DBTN30_n12 FE_DBTN16_n1450
+ destinationAddressbuffer[5][2] AOI22X1TS
XU1870 n1748 FE_DBTN18_n241 destinationAddressIn_WEST[2] n223
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1871 n1747 FE_DBTN39_n2 destinationAddressIn_NORTH[2] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1872 n1758 readRequesterAddress[3] FE_DBTN30_n12 FE_DBTN16_n1450
+ destinationAddressbuffer[5][3] AOI22X1TS
XU1873 n1757 FE_DBTN18_n241 destinationAddressIn_WEST[3] n223
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1874 n1756 FE_DBTN39_n2 destinationAddressIn_NORTH[3] FE_DBTN17_n253
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1875 n1763 readRequesterAddress[0] n274 FE_DBTN13_n1419
+ destinationAddressbuffer[4][0] AOI22X1TS
XU1876 n1762 FE_DBTN14_n289 destinationAddressIn_WEST[0] n273
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1877 n1761 FE_DBTN33_n9 destinationAddressIn_SOUTH[0] FE_DBTN31_n11
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1878 n1771 readRequesterAddress[1] n274 FE_DBTN13_n1419
+ destinationAddressbuffer[4][1] AOI22X1TS
XU1879 n1770 FE_DBTN14_n289 destinationAddressIn_WEST[1] n273
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1880 n1769 FE_DBTN33_n9 destinationAddressIn_SOUTH[1] FE_DBTN31_n11
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1881 n1781 readRequesterAddress[2] n274 FE_DBTN13_n1419
+ destinationAddressbuffer[4][2] AOI22X1TS
XU1882 n1780 FE_DBTN14_n289 destinationAddressIn_WEST[2] n273
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1883 n1779 FE_DBTN33_n9 destinationAddressIn_SOUTH[2] FE_DBTN31_n11
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1884 n1787 readRequesterAddress[3] n274 FE_DBTN13_n1419
+ destinationAddressbuffer[4][3] AOI22X1TS
XU1885 n1786 FE_DBTN14_n289 destinationAddressIn_WEST[3] n273
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1886 n1785 FE_DBTN33_n9 destinationAddressIn_SOUTH[3] FE_DBTN31_n11
+ destinationAddressIn_NORTH[3] AOI22X1TS
XU1887 n1794 readRequesterAddress[0] n133 FE_DBTN22_n1390
+ destinationAddressbuffer[3][0] AOI22X1TS
XU1888 n1793 n137 destinationAddressIn_WEST[0] n146
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1889 n1792 n147 destinationAddressIn_NORTH[0] n132
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1890 n1801 readRequesterAddress[1] n133 FE_DBTN22_n1390
+ destinationAddressbuffer[3][1] AOI22X1TS
XU1891 n1800 n137 destinationAddressIn_WEST[1] n146
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1892 n1799 n147 destinationAddressIn_NORTH[1] n132
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1893 n1806 readRequesterAddress[2] n133 FE_DBTN22_n1390
+ destinationAddressbuffer[3][2] AOI22X1TS
XU1894 n1805 n137 destinationAddressIn_WEST[2] n146
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1895 n1804 n147 destinationAddressIn_NORTH[2] n132
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1896 n1816 readRequesterAddress[3] n133 FE_DBTN22_n1390
+ destinationAddressbuffer[3][3] AOI22X1TS
XU1897 n1815 n137 destinationAddressIn_WEST[3] n146
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1898 n1814 n147 destinationAddressIn_NORTH[3] n132
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1899 n1821 readRequesterAddress[0] FE_DBTN32_n10 FE_DBTN20_n1356
+ destinationAddressbuffer[2][0] AOI22X1TS
XU1900 n1820 FE_DBTN21_n198 destinationAddressIn_WEST[0] n183
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1901 n1819 n191 destinationAddressIn_NORTH[0] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1902 n1828 readRequesterAddress[1] FE_DBTN32_n10 FE_DBTN20_n1356
+ destinationAddressbuffer[2][1] AOI22X1TS
XU1903 n1827 FE_DBTN21_n198 destinationAddressIn_WEST[1] n183
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1904 n1826 n191 destinationAddressIn_NORTH[1] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1905 n1836 readRequesterAddress[2] FE_DBTN32_n10 FE_DBTN20_n1356
+ destinationAddressbuffer[2][2] AOI22X1TS
XU1906 n1835 FE_DBTN21_n198 destinationAddressIn_WEST[2] n183
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1907 n1834 n191 destinationAddressIn_NORTH[2] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1908 n1843 readRequesterAddress[3] FE_DBTN32_n10 FE_DBTN20_n1356
+ destinationAddressbuffer[2][3] AOI22X1TS
XU1909 n1842 FE_DBTN21_n198 destinationAddressIn_WEST[3] n183
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1910 n1841 n191 destinationAddressIn_NORTH[3] FE_DBTN37_n4
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1911 n1852 readRequesterAddress[0] n317 FE_DBTN10_n356
+ destinationAddressbuffer[1][0] AOI22X1TS
XU1912 n1851 FE_DBTN11_n343 destinationAddressIn_WEST[0] n315
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1913 n1850 n338 destinationAddressIn_NORTH[0] n324
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1914 n1863 readRequesterAddress[1] n317 FE_DBTN10_n356
+ destinationAddressbuffer[1][1] AOI22X1TS
XU1915 n1862 FE_DBTN11_n343 destinationAddressIn_WEST[1] n315
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1916 n1861 n338 destinationAddressIn_NORTH[1] n324
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1917 n1876 readRequesterAddress[2] n317 FE_DBTN10_n356
+ destinationAddressbuffer[1][2] AOI22X1TS
XU1918 n1875 FE_DBTN11_n343 destinationAddressIn_WEST[2] n315
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1919 n1874 n338 destinationAddressIn_NORTH[2] n324
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1920 n1886 readRequesterAddress[3] n317 FE_DBTN10_n356
+ destinationAddressbuffer[1][3] AOI22X1TS
XU1921 n1885 FE_DBTN11_n343 destinationAddressIn_WEST[3] n315
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1922 n1884 n338 destinationAddressIn_NORTH[3] n324
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1923 n1893 readRequesterAddress[0] FE_DBTN29_n13 FE_DBTN6_n425
+ destinationAddressbuffer[0][0] AOI22X1TS
XU1924 n1892 FE_DBTN7_n415 destinationAddressIn_WEST[0] FE_DBTN40_n1
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1925 n1891 FE_DBTN35_n6 destinationAddressIn_SOUTH[0] FE_DBTN36_n5
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1926 n1904 readRequesterAddress[1] FE_DBTN29_n13 FE_DBTN6_n425
+ destinationAddressbuffer[0][1] AOI22X1TS
XU1927 n1903 FE_DBTN7_n415 destinationAddressIn_WEST[1] FE_DBTN40_n1
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1928 n1902 FE_DBTN35_n6 destinationAddressIn_SOUTH[1] FE_DBTN36_n5
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1929 n1915 readRequesterAddress[2] FE_DBTN29_n13 FE_DBTN6_n425
+ destinationAddressbuffer[0][2] AOI22X1TS
XU1930 n1914 FE_DBTN7_n415 destinationAddressIn_WEST[2] FE_DBTN40_n1
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1931 n1913 FE_DBTN35_n6 destinationAddressIn_SOUTH[2] FE_DBTN36_n5
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1932 n1925 readRequesterAddress[3] FE_DBTN29_n13 FE_DBTN6_n425
+ destinationAddressbuffer[0][3] AOI22X1TS
XU1933 n1924 FE_DBTN7_n415 destinationAddressIn_WEST[3] FE_DBTN40_n1
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1934 n1923 FE_DBTN35_n6 destinationAddressIn_SOUTH[3] FE_DBTN36_n5
+ destinationAddressIn_NORTH[3] AOI22X1TS
.ENDS

.SUBCKT outputPortArbiter_2 clk reset selectBit_NORTH
+ destinationAddressIn_NORTH[11] destinationAddressIn_NORTH[10]
+ destinationAddressIn_NORTH[9] destinationAddressIn_NORTH[8]
+ destinationAddressIn_NORTH[7] destinationAddressIn_NORTH[6]
+ destinationAddressIn_NORTH[5] destinationAddressIn_NORTH[4]
+ destinationAddressIn_NORTH[3] destinationAddressIn_NORTH[2]
+ destinationAddressIn_NORTH[1] destinationAddressIn_NORTH[0]
+ requesterAddressIn_NORTH[3] requesterAddressIn_NORTH[2]
+ requesterAddressIn_NORTH[1] requesterAddressIn_NORTH[0] readIn_NORTH
+ writeIn_NORTH dataIn_NORTH[5] dataIn_NORTH[4] dataIn_NORTH[3] dataIn_NORTH[2]
+ dataIn_NORTH[1] dataIn_NORTH[0] selectBit_SOUTH
+ destinationAddressIn_SOUTH[11] destinationAddressIn_SOUTH[10]
+ destinationAddressIn_SOUTH[9] destinationAddressIn_SOUTH[8]
+ destinationAddressIn_SOUTH[7] destinationAddressIn_SOUTH[6]
+ destinationAddressIn_SOUTH[5] destinationAddressIn_SOUTH[4]
+ destinationAddressIn_SOUTH[3] destinationAddressIn_SOUTH[2]
+ destinationAddressIn_SOUTH[1] destinationAddressIn_SOUTH[0]
+ requesterAddressIn_SOUTH[3] requesterAddressIn_SOUTH[2]
+ requesterAddressIn_SOUTH[1] requesterAddressIn_SOUTH[0] readIn_SOUTH
+ writeIn_SOUTH dataIn_SOUTH[5] dataIn_SOUTH[4] dataIn_SOUTH[3] dataIn_SOUTH[2]
+ dataIn_SOUTH[1] dataIn_SOUTH[0] selectBit_EAST destinationAddressIn_EAST[11]
+ destinationAddressIn_EAST[10] destinationAddressIn_EAST[9]
+ destinationAddressIn_EAST[8] destinationAddressIn_EAST[7]
+ destinationAddressIn_EAST[6] destinationAddressIn_EAST[5]
+ destinationAddressIn_EAST[4] destinationAddressIn_EAST[3]
+ destinationAddressIn_EAST[2] destinationAddressIn_EAST[1]
+ destinationAddressIn_EAST[0] requesterAddressIn_EAST[3]
+ requesterAddressIn_EAST[2] requesterAddressIn_EAST[1]
+ requesterAddressIn_EAST[0] readIn_EAST writeIn_EAST dataIn_EAST[5]
+ dataIn_EAST[4] dataIn_EAST[3] dataIn_EAST[2] dataIn_EAST[1] dataIn_EAST[0]
+ selectBit_WEST destinationAddressIn_WEST[11] destinationAddressIn_WEST[10]
+ destinationAddressIn_WEST[9] destinationAddressIn_WEST[8]
+ destinationAddressIn_WEST[7] destinationAddressIn_WEST[6]
+ destinationAddressIn_WEST[5] destinationAddressIn_WEST[4]
+ destinationAddressIn_WEST[3] destinationAddressIn_WEST[2]
+ destinationAddressIn_WEST[1] destinationAddressIn_WEST[0]
+ requesterAddressIn_WEST[3] requesterAddressIn_WEST[2]
+ requesterAddressIn_WEST[1] requesterAddressIn_WEST[0] readIn_WEST
+ writeIn_WEST dataIn_WEST[5] dataIn_WEST[4] dataIn_WEST[3] dataIn_WEST[2]
+ dataIn_WEST[1] dataIn_WEST[0] readReady readRequesterAddress[3]
+ readRequesterAddress[2] readRequesterAddress[1] readRequesterAddress[0]
+ cacheDataOut[5] cacheDataOut[4] cacheDataOut[3] cacheDataOut[2]
+ cacheDataOut[1] cacheDataOut[0] destinationAddressOut[11]
+ destinationAddressOut[10] destinationAddressOut[9] destinationAddressOut[8]
+ destinationAddressOut[7] destinationAddressOut[6] destinationAddressOut[5]
+ destinationAddressOut[4] destinationAddressOut[3] destinationAddressOut[2]
+ destinationAddressOut[1] destinationAddressOut[0] requesterAddressOut[3]
+ requesterAddressOut[2] requesterAddressOut[1] requesterAddressOut[0] readOut
+ writeOut dataOut[5] dataOut[4] dataOut[3] dataOut[2] dataOut[1] dataOut[0]
XFE_DBTC215_readInBuffer_EAST FE_DBTN215_readInBuffer_EAST readIn_EAST INVX2TS
XFE_DBTC214_writeInBuffer_EAST FE_DBTN214_writeInBuffer_EAST writeIn_EAST
+ INVX2TS
XFE_DBTC212_destinationAddressInBuffer_EAST_11_
+ FE_DBTN212_destinationAddressInBuffer_EAST_11_ destinationAddressIn_EAST[11]
+ INVX2TS
XFE_DBTC209_destinationAddressInBuffer_EAST_10_
+ FE_DBTN209_destinationAddressInBuffer_EAST_10_ destinationAddressIn_EAST[10]
+ INVX2TS
XFE_DBTC206_destinationAddressInBuffer_EAST_9_
+ FE_DBTN206_destinationAddressInBuffer_EAST_9_ destinationAddressIn_EAST[9]
+ INVX2TS
XFE_DBTC203_destinationAddressInBuffer_EAST_8_
+ FE_DBTN203_destinationAddressInBuffer_EAST_8_ destinationAddressIn_EAST[8]
+ INVX2TS
XFE_DBTC199_destinationAddressInBuffer_EAST_7_
+ FE_DBTN199_destinationAddressInBuffer_EAST_7_ destinationAddressIn_EAST[7]
+ INVX2TS
XFE_DBTC196_destinationAddressInBuffer_EAST_6_
+ FE_DBTN196_destinationAddressInBuffer_EAST_6_ destinationAddressIn_EAST[6]
+ INVX2TS
XFE_DBTC193_destinationAddressInBuffer_EAST_5_
+ FE_DBTN193_destinationAddressInBuffer_EAST_5_ destinationAddressIn_EAST[5]
+ INVX2TS
XFE_DBTC190_destinationAddressInBuffer_EAST_4_
+ FE_DBTN190_destinationAddressInBuffer_EAST_4_ destinationAddressIn_EAST[4]
+ INVX2TS
XFE_DBTC81_n1 FE_DBTN81_n1 n1 INVX2TS
XFE_DBTC80_n2 FE_DBTN80_n2 n2 INVX2TS
XFE_DBTC79_n3 FE_DBTN79_n3 n3 INVX2TS
XFE_DBTC78_n4 FE_DBTN78_n4 n4 INVX2TS
XFE_DBTC77_n5 FE_DBTN77_n5 n5 INVX2TS
XFE_DBTC76_n6 FE_DBTN76_n6 n6 INVX2TS
XFE_DBTC75_n7 FE_DBTN75_n7 n7 INVX2TS
XFE_DBTC74_n8 FE_DBTN74_n8 n8 INVX2TS
XFE_DBTC73_n9 FE_DBTN73_n9 n9 INVX2TS
XFE_DBTC72_n11 FE_DBTN72_n11 n11 INVX2TS
XFE_DBTC71_n12 FE_DBTN71_n12 n12 INVX2TS
XFE_DBTC70_n59 FE_DBTN70_n59 n59 INVX2TS
XFE_DBTC69_n1527 FE_DBTN69_n1527 n1527 INVX2TS
XFE_DBTC68_n55 FE_DBTN68_n55 n55 INVX2TS
XFE_DBTC67_n1937 FE_DBTN67_n1937 n1937 INVX2TS
XFE_DBTC66_n1475 FE_DBTN66_n1475 n1475 INVX2TS
XFE_DBTC65_n106 FE_DBTN65_n106 n106 INVX2TS
XFE_DBTC64_n133 FE_DBTN64_n133 n133 INVX2TS
XFE_DBTC63_n1377 FE_DBTN63_n1377 n1377 INVX2TS
XFE_DBTC62_n163 FE_DBTN62_n163 n163 INVX2TS
XFE_DBTC61_n197 FE_DBTN61_n197 n197 INVX2TS
XFE_DBTC60_n1343 FE_DBTN60_n1343 n1343 INVX2TS
XFE_DBTC59_n239 FE_DBTN59_n239 n239 INVX2TS
XFE_DBTC58_n245 FE_DBTN58_n245 n245 INVX2TS
XFE_DBTC57_n1438 FE_DBTN57_n1438 n1438 INVX2TS
XFE_DBTC56_n1935 FE_DBTN56_n1935 n1935 INVX2TS
XFE_DBTC55_n289 FE_DBTN55_n289 n289 INVX2TS
XFE_DBTC54_n1406 FE_DBTN54_n1406 n1406 INVX2TS
XFE_DBTC53_n341 FE_DBTN53_n341 n341 INVX2TS
XFE_DBTC52_n354 FE_DBTN52_n354 n354 INVX2TS
XFE_DBTC51_n1932 FE_DBTN51_n1932 n1932 INVX2TS
XFE_DBTC50_n1929 FE_DBTN50_n1929 n1929 INVX2TS
XFE_DBTC49_n422 FE_DBTN49_n422 n422 INVX2TS
XFE_DBTC48_n416 FE_DBTN48_n416 n416 INVX2TS
XFE_DBTC47_n1933 FE_DBTN47_n1933 n1933 INVX2TS
XFE_DBTC46_n1934 FE_DBTN46_n1934 n1934 INVX2TS
XFE_DBTC45_n672 FE_DBTN45_n672 n672 INVX2TS
XFE_DBTC44_n1936 FE_DBTN44_n1936 n1936 INVX2TS
XFE_DBTC43_n1928 FE_DBTN43_n1928 n1928 INVX2TS
XFE_DBTC42_n1927 FE_DBTN42_n1927 n1927 INVX2TS
XFE_DBTC41_n558 FE_DBTN41_n558 n558 INVX2TS
Xfull_reg_reg 1000 n1938 clk N2624 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][0] requesterAddressbuffer[2][0] 1001 clk n1998
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][1] requesterAddressbuffer[2][1] 1002 clk n1999
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][2] requesterAddressbuffer[2][2] 1003 clk n2000
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][3] requesterAddressbuffer[2][3] 1004 clk n2001
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][0] destinationAddressbuffer[2][0] 1005 clk
+ n2134 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][1] destinationAddressbuffer[2][1] 1006 clk
+ n2135 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][2] destinationAddressbuffer[2][2] 1007 clk
+ n2136 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][3] destinationAddressbuffer[2][3] 1008 clk
+ n2137 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][0] dataoutbuffer[0][0] 1009 clk n2010 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][1] dataoutbuffer[0][1] 1010 clk n2011 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][2] dataoutbuffer[0][2] 1011 clk n2012 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][3] dataoutbuffer[0][3] 1012 clk n2013 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][4] dataoutbuffer[0][4] 1013 clk n2014 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][5] dataoutbuffer[0][5] 1014 clk n2015 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[7] writeOutbuffer[7] 1015 clk n2058 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][4] destinationAddressbuffer[7][4] 1016 clk
+ n2078 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][5] destinationAddressbuffer[7][5] 1017 clk
+ n2079 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][6] destinationAddressbuffer[7][6] 1018 clk
+ n2080 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][7] destinationAddressbuffer[7][7] 1019 clk
+ n2081 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][8] destinationAddressbuffer[7][8] 1020 clk
+ n2082 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][9] destinationAddressbuffer[7][9] 1021 clk
+ n2083 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][11] destinationAddressbuffer[7][11] 1022 clk
+ n2085 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[6] writeOutbuffer[6] 1023 clk n2059 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][4] destinationAddressbuffer[6][4] 1024 clk
+ n2090 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][5] destinationAddressbuffer[6][5] 1025 clk
+ n2091 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][6] destinationAddressbuffer[6][6] 1026 clk
+ n2092 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][7] destinationAddressbuffer[6][7] 1027 clk
+ n2093 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][8] destinationAddressbuffer[6][8] 1028 clk
+ n2094 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][9] destinationAddressbuffer[6][9] 1029 clk
+ n2095 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][10] destinationAddressbuffer[6][10] 1030 clk
+ n2096 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][11] destinationAddressbuffer[6][11] 1031 clk
+ n2097 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[3] writeOutbuffer[3] 1032 clk n2062 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][4] destinationAddressbuffer[3][4] 1033 clk
+ n2126 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][5] destinationAddressbuffer[3][5] 1034 clk
+ n2127 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][6] destinationAddressbuffer[3][6] 1035 clk
+ n2128 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][7] destinationAddressbuffer[3][7] 1036 clk
+ n2129 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][8] destinationAddressbuffer[3][8] 1037 clk
+ n2130 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][9] destinationAddressbuffer[3][9] 1038 clk
+ n2131 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][10] destinationAddressbuffer[3][10] 1039 clk
+ n2132 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][11] destinationAddressbuffer[3][11] 1040 clk
+ n2133 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[2] writeOutbuffer[2] 1041 clk n2063 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][4] destinationAddressbuffer[2][4] 1042 clk
+ n2138 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][5] destinationAddressbuffer[2][5] 1043 clk
+ n2139 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][6] destinationAddressbuffer[2][6] 1044 clk
+ n2140 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][7] destinationAddressbuffer[2][7] 1045 clk
+ n2141 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][8] destinationAddressbuffer[2][8] 1046 clk
+ n2142 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][9] destinationAddressbuffer[2][9] 1047 clk
+ n2143 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][10] destinationAddressbuffer[2][10] 1048 clk
+ n2144 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][11] destinationAddressbuffer[2][11] 1049 clk
+ n2145 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][0] dataoutbuffer[7][0] 1050 clk n2052 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][1] dataoutbuffer[7][1] 1051 clk n2053 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][2] dataoutbuffer[7][2] 1052 clk n2054 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][3] dataoutbuffer[7][3] 1053 clk n2055 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][4] dataoutbuffer[7][4] 1054 clk n2056 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][5] dataoutbuffer[7][5] 1055 clk n2057 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][0] dataoutbuffer[6][0] 1056 clk n2046 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][1] dataoutbuffer[6][1] 1057 clk n2047 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][2] dataoutbuffer[6][2] 1058 clk n2048 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][3] dataoutbuffer[6][3] 1059 clk n2049 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][4] dataoutbuffer[6][4] 1060 clk n2050 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][5] dataoutbuffer[6][5] 1061 clk n2051 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][0] requesterAddressbuffer[5][0] 1062 clk n1986
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][1] requesterAddressbuffer[5][1] 1063 clk n1987
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][2] requesterAddressbuffer[5][2] 1064 clk n1988
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][3] requesterAddressbuffer[5][3] 1065 clk n1989
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][0] destinationAddressbuffer[5][0] 1066 clk
+ n2098 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][1] destinationAddressbuffer[5][1] 1067 clk
+ n2099 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][2] destinationAddressbuffer[5][2] 1068 clk
+ n2100 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][3] destinationAddressbuffer[5][3] 1069 clk
+ n2101 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][0] requesterAddressbuffer[4][0] 1070 clk n1990
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][1] requesterAddressbuffer[4][1] 1071 clk n1991
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][2] requesterAddressbuffer[4][2] 1072 clk n1992
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][3] requesterAddressbuffer[4][3] 1073 clk n1993
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][0] destinationAddressbuffer[4][0] 1074 clk
+ n2110 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][1] destinationAddressbuffer[4][1] 1075 clk
+ n2111 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][2] destinationAddressbuffer[4][2] 1076 clk
+ n2112 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][3] destinationAddressbuffer[4][3] 1077 clk
+ n2113 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][0] dataoutbuffer[3][0] 1078 clk n2028 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][1] dataoutbuffer[3][1] 1079 clk n2029 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][2] dataoutbuffer[3][2] 1080 clk n2030 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][3] dataoutbuffer[3][3] 1081 clk n2031 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][4] dataoutbuffer[3][4] 1082 clk n2032 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][5] dataoutbuffer[3][5] 1083 clk n2033 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][0] dataoutbuffer[2][0] 1084 clk n2022 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][1] dataoutbuffer[2][1] 1085 clk n2023 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][2] dataoutbuffer[2][2] 1086 clk n2024 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][3] dataoutbuffer[2][3] 1087 clk n2025 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][4] dataoutbuffer[2][4] 1088 clk n2026 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][5] dataoutbuffer[2][5] 1089 clk n2027 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][0] requesterAddressbuffer[1][0] 1090 clk n2002
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][1] requesterAddressbuffer[1][1] 1091 clk n2003
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][2] requesterAddressbuffer[1][2] 1092 clk n2004
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][3] requesterAddressbuffer[1][3] 1093 clk n2005
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][0] destinationAddressbuffer[1][0] 1094 clk
+ n2146 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][1] destinationAddressbuffer[1][1] 1095 clk
+ n2147 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][2] destinationAddressbuffer[1][2] 1096 clk
+ n2148 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][3] destinationAddressbuffer[1][3] 1097 clk
+ n2149 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][0] requesterAddressbuffer[0][0] 1098 clk n2006
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][1] requesterAddressbuffer[0][1] 1099 clk n2007
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][2] requesterAddressbuffer[0][2] 1100 clk n2008
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][3] requesterAddressbuffer[0][3] 1101 clk n2009
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][0] destinationAddressbuffer[0][0] 1102 clk
+ n2158 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][1] destinationAddressbuffer[0][1] 1103 clk
+ n2159 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][2] destinationAddressbuffer[0][2] 1104 clk
+ n2160 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][3] destinationAddressbuffer[0][3] 1105 clk
+ n2161 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][0] requesterAddressbuffer[7][0] 1106 clk n1978
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][1] requesterAddressbuffer[7][1] 1107 clk n1979
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][2] requesterAddressbuffer[7][2] 1108 clk n1980
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][3] requesterAddressbuffer[7][3] 1109 clk n1981
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][0] destinationAddressbuffer[7][0] 1110 clk
+ n2074 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][1] destinationAddressbuffer[7][1] 1111 clk
+ n2075 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][2] destinationAddressbuffer[7][2] 1112 clk
+ n2076 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][3] destinationAddressbuffer[7][3] 1113 clk
+ n2077 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][0] requesterAddressbuffer[6][0] 1114 clk n1982
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][1] requesterAddressbuffer[6][1] 1115 clk n1983
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][2] requesterAddressbuffer[6][2] 1116 clk n1984
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][3] requesterAddressbuffer[6][3] 1117 clk n1985
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][0] destinationAddressbuffer[6][0] 1118 clk
+ n2086 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][1] destinationAddressbuffer[6][1] 1119 clk
+ n2087 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][2] destinationAddressbuffer[6][2] 1120 clk
+ n2088 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][3] destinationAddressbuffer[6][3] 1121 clk
+ n2089 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][0] dataoutbuffer[5][0] 1122 clk n2040 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][1] dataoutbuffer[5][1] 1123 clk n2041 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][2] dataoutbuffer[5][2] 1124 clk n2042 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][3] dataoutbuffer[5][3] 1125 clk n2043 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][4] dataoutbuffer[5][4] 1126 clk n2044 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][5] dataoutbuffer[5][5] 1127 clk n2045 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][0] dataoutbuffer[4][0] 1128 clk n2034 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][1] dataoutbuffer[4][1] 1129 clk n2035 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][2] dataoutbuffer[4][2] 1130 clk n2036 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][3] dataoutbuffer[4][3] 1131 clk n2037 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][4] dataoutbuffer[4][4] 1132 clk n2038 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][5] dataoutbuffer[4][5] 1133 clk n2039 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][0] requesterAddressbuffer[3][0] 1134 clk n1994
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][1] requesterAddressbuffer[3][1] 1135 clk n1995
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][2] requesterAddressbuffer[3][2] 1136 clk n1996
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][3] requesterAddressbuffer[3][3] 1137 clk n1997
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][0] destinationAddressbuffer[3][0] 1138 clk
+ n2122 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][1] destinationAddressbuffer[3][1] 1139 clk
+ n2123 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][2] destinationAddressbuffer[3][2] 1140 clk
+ n2124 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][3] destinationAddressbuffer[3][3] 1141 clk
+ n2125 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][0] dataoutbuffer[1][0] 1142 clk n2016 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][1] dataoutbuffer[1][1] 1143 clk n2017 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][2] dataoutbuffer[1][2] 1144 clk n2018 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][3] dataoutbuffer[1][3] 1145 clk n2019 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][4] dataoutbuffer[1][4] 1146 clk n2020 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][5] dataoutbuffer[1][5] 1147 clk n2021 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[5] writeOutbuffer[5] 1148 clk n2060 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][4] destinationAddressbuffer[5][4] 1149 clk
+ n2102 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][5] destinationAddressbuffer[5][5] 1150 clk
+ n2103 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][6] destinationAddressbuffer[5][6] 1151 clk
+ n2104 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][7] destinationAddressbuffer[5][7] 1152 clk
+ n2105 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][8] destinationAddressbuffer[5][8] 1153 clk
+ n2106 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][9] destinationAddressbuffer[5][9] 1154 clk
+ n2107 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][10] destinationAddressbuffer[5][10] 1155 clk
+ n2108 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][11] destinationAddressbuffer[5][11] 1156 clk
+ n2109 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[4] writeOutbuffer[4] 1157 clk n2061 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][4] destinationAddressbuffer[4][4] 1158 clk
+ n2114 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][5] destinationAddressbuffer[4][5] 1159 clk
+ n2115 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][6] destinationAddressbuffer[4][6] 1160 clk
+ n2116 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][7] destinationAddressbuffer[4][7] 1161 clk
+ n2117 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][8] destinationAddressbuffer[4][8] 1162 clk
+ n2118 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][9] destinationAddressbuffer[4][9] 1163 clk
+ n2119 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][10] destinationAddressbuffer[4][10] 1164 clk
+ n2120 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][11] destinationAddressbuffer[4][11] 1165 clk
+ n2121 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[1] writeOutbuffer[1] 1166 clk n2064 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][4] destinationAddressbuffer[1][4] 1167 clk
+ n2150 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][5] destinationAddressbuffer[1][5] 1168 clk
+ n2151 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][6] destinationAddressbuffer[1][6] 1169 clk
+ n2152 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][7] destinationAddressbuffer[1][7] 1170 clk
+ n2153 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][8] destinationAddressbuffer[1][8] 1171 clk
+ n2154 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][9] destinationAddressbuffer[1][9] 1172 clk
+ n2155 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][10] destinationAddressbuffer[1][10] 1173 clk
+ n2156 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][11] destinationAddressbuffer[1][11] 1174 clk
+ n2157 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[0] writeOutbuffer[0] 1175 clk n2065 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][4] destinationAddressbuffer[0][4] 1176 clk
+ n2162 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][5] destinationAddressbuffer[0][5] 1177 clk
+ n2163 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][6] destinationAddressbuffer[0][6] 1178 clk
+ n2164 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][7] destinationAddressbuffer[0][7] 1179 clk
+ n2165 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][8] destinationAddressbuffer[0][8] 1180 clk
+ n2166 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][9] destinationAddressbuffer[0][9] 1181 clk
+ n2167 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][10] destinationAddressbuffer[0][10] 1182 clk
+ n2168 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][11] destinationAddressbuffer[0][11] 1183 clk
+ n2169 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][10] destinationAddressbuffer[7][10] 1184 clk
+ n2084 VDD VDD DFFNSRX1TS
XwriteOut_reg writeOut 1185 clk n1955 VDD VDD DFFNSRX1TS
XdestinationAddressOut_reg[4] destinationAddressOut[4] 1186 clk n1964 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[5] destinationAddressOut[5] 1187 clk n1965 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[6] destinationAddressOut[6] 1188 clk n1966 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[7] destinationAddressOut[7] 1189 clk n1967 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[8] destinationAddressOut[8] 1190 clk n1968 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[9] destinationAddressOut[9] 1191 clk n1969 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[10] destinationAddressOut[10] 1192 clk n1970 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[11] destinationAddressOut[11] 1193 clk n1971 VDD VDD
+ DFFNSRX1TS
XreadOut_reg readOut 1194 clk n1954 VDD VDD DFFNSRX1TS
XrequesterAddressOut_reg[0] requesterAddressOut[0] 1195 clk n1956 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[1] requesterAddressOut[1] 1196 clk n1957 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[2] requesterAddressOut[2] 1197 clk n1958 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[3] requesterAddressOut[3] 1198 clk n1959 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[0] destinationAddressOut[0] 1199 clk n1960 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[1] destinationAddressOut[1] 1200 clk n1961 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[2] destinationAddressOut[2] 1201 clk n1962 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[3] destinationAddressOut[3] 1202 clk n1963 VDD VDD
+ DFFNSRX1TS
XdataOut_reg[0] dataOut[0] 1203 clk n1972 VDD VDD DFFNSRX1TS
XdataOut_reg[1] dataOut[1] 1204 clk n1973 VDD VDD DFFNSRX1TS
XdataOut_reg[2] dataOut[2] 1205 clk n1974 VDD VDD DFFNSRX1TS
XdataOut_reg[3] dataOut[3] 1206 clk n1975 VDD VDD DFFNSRX1TS
XdataOut_reg[4] dataOut[4] 1207 clk n1976 VDD VDD DFFNSRX1TS
XdataOut_reg[5] dataOut[5] 1208 clk n1977 VDD VDD DFFNSRX1TS
Xread_reg_reg[1] n1931 n1930 clk n1953 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[0] n1929 n1933 clk n1948 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[2] n1934 n1935 clk n1950 VDD VDD DFFNSRX1TS
Xread_reg_reg[0] n1924 n1936 clk n1947 VDD VDD DFFNSRX1TS
Xread_reg_reg[2] n1927 n1928 clk n1952 VDD VDD DFFNSRX1TS
Xempty_reg_reg n1926 n1925 clk n1951 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[7] readOutbuffer[7] n1939 clk n2066 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[6] readOutbuffer[6] n1940 clk n2067 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[4] readOutbuffer[4] n1942 clk n2069 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[5] readOutbuffer[5] n1941 clk n2068 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[1] readOutbuffer[1] n1945 clk n2072 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[2] readOutbuffer[2] n1944 clk n2071 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[0] readOutbuffer[0] n1946 clk n2073 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[1] n1932 n1937 clk n1949 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[3] readOutbuffer[3] n1943 clk n2070 VDD VDD DFFNSRX1TS
XU3 n470 n492 n475 FE_DBTN67_n1937 n474 CMPR32X2TS
XU4 n453 n467 selectBit_WEST readReady n450 CMPR32X2TS
XU5 n454 n450 selectBit_SOUTH selectBit_NORTH selectBit_EAST CMPR32X2TS
XU6 n18 FE_DBTN50_n1929 n503 NOR2XLTS
XU8 n518 n515 n536 n514 n537 OAI31X1TS
XU9 n51 n1563 n38 NOR2XLTS
XU10 n16 n15 FE_DBTN47_n1933 n450 ADDHXLTS
XU12 n511 selectBit_EAST INVX2TS
XU13 n1641 n14 n78 n380 NOR3X1TS
XU14 n322 n1632 n321 NOR2XLTS
XU15 n315 FE_DBTN64_n133 n1642 NOR2XLTS
XU16 n186 n1619 n185 NOR2XLTS
XU17 n134 FE_DBTN64_n133 n1616 NOR2XLTS
XU18 n272 n1606 n1600 n277 NOR3XLTS
XU19 n222 FE_DBTN64_n133 n1595 NOR2XLTS
XU20 n86 FE_DBTN64_n133 n1582 NOR2XLTS
XU21 n34 n1571 FE_DBTN64_n133 NOR2XLTS
XU22 n92 n1574 n91 NOR2X1TS
XU23 n199 n1621 n185 NOR2X1TS
XU24 n395 n394 n393 NAND2BXLTS
XU25 n185 n184 n183 NAND2BXLTS
XU26 n321 n319 n318 NAND2BX1TS
XU27 n91 n89 n88 NAND2BXLTS
XU28 n278 n277 n276 NAND2BXLTS
XU29 n1612 n127 n382 NOR2X1TS
XU30 n382 n126 selectBit_EAST NAND2BX1TS
XU31 n1585 n24 n219 FE_DBTN73_n9 NAND3X1TS
XU32 n1563 FE_DBTN67_n1937 n24 n219 NAND3X1TS
XU33 n309 n219 FE_DBTN73_n9 NOR2X1TS
XU34 n274 FE_DBTN64_n133 n1607 NOR2X1TS
XU35 n1628 n15 n178 n380 NOR3X1TS
XU36 n133 n522 n1938 AND2X2TS
XU37 n380 n125 selectBit_WEST NAND2BX1TS
XU38 n506 selectBit_WEST selectBit_EAST readReady NOR3X1TS
XU39 n17 n14 n454 FE_DBTN67_n1937 n16 ADDFX1TS
XU42 n1606 n14 n15 n266 NOR3X1TS
XU43 n225 n1594 n1591 NOR2XLTS
XU44 n536 readReady selectBit_WEST selectBit_EAST NOR3BXLTS
XU45 n1406 n275 n274 OR2X1TS
XU46 n1438 n223 n222 OR2X1TS
XU47 n1343 n181 FE_DBTN72_n11 OR2X1TS
XU48 n1377 n135 n134 OR2X1TS
XU49 n1475 n87 n86 OR2X1TS
XU50 n1527 n35 n34 OR2X1TS
XU51 n1616 FE_DBTN67_n1937 n1929 readReady FE_DBTN46_n1934 NAND4XLTS
XU53 n1647 n1650 INVX2TS
XU54 n1619 n1621 INVX2TS
XU55 n1622 n1625 INVX2TS
XU57 n1642 FE_DBTN47_n1933 readReady FE_DBTN46_n1934 FE_DBTN51_n1932 NAND4XLTS
XU58 n1632 n1634 INVX2TS
XU59 n1635 n1637 INVX2TS
XU60 n1595 FE_DBTN47_n1933 FE_DBTN56_n1935 readReady FE_DBTN51_n1932 NAND4XLTS
XU61 n1594 n14 n78 n266 NOR3X1TS
XU63 n1607 FE_DBTN56_n1935 readReady FE_DBTN50_n1929 FE_DBTN51_n1932 NAND4XLTS
XU64 n1600 n1602 INVX2TS
XU66 n1582 FE_DBTN67_n1937 FE_DBTN56_n1935 readReady FE_DBTN50_n1929 NAND4XLTS
XU67 n1581 n15 n178 n266 NOR3X1TS
XU68 n1574 n1575 INVX2TS
XU69 n1576 n1578 INVX2TS
XU71 n1571 FE_DBTN47_n1933 FE_DBTN67_n1937 FE_DBTN56_n1935 readReady NAND4XLTS
XU72 n1565 n1567 INVX2TS
XU74 n558 n537 n1926 n536 NAND3XLTS
XU75 n549 n522 FE_DBTN45_n672 CLKAND2X2TS
XU76 n473 n469 n467 CLKAND2X2TS
XU77 n503 selectBit_NORTH INVX2TS
XU78 n276 n1606 n1602 NOR2XLTS
XU79 n36 n1570 n1567 NOR2XLTS
XU80 n445 n458 n529 FE_DBTN51_n1932 n455 ADDFX1TS
XU81 n393 n1654 n1650 NOR2XLTS
XU82 n21 FE_DBTN50_n1929 n503 n18 AO21X1TS
XU83 n126 n28 n23 n26 OAI21XLTS
XU84 n517 selectBit_NORTH n506 n505 NAND3XLTS
XU85 n516 selectBit_SOUTH n506 n503 NAND3XLTS
XU86 n318 n1641 n1637 NOR2XLTS
XU87 n131 n1615 n1612 NOR2XLTS
XU88 n183 n1628 n1625 NOR2XLTS
XU89 n227 n226 n225 NAND2BXLTS
XU90 n220 n18 FE_DBTN56_n1935 FE_DBTN51_n1932 NAND3XLTS
XU91 n88 n1581 n1578 NOR2XLTS
XU92 n137 n135 n1616 NAND2X1TS
XU93 n38 n37 n36 NAND2BXLTS
XU94 n464 n445 n447 XOR2XLTS
XU95 n448 FE_DBTN67_n1937 n1930 n447 OAI21XLTS
XU96 n28 n10 FE_DBTN73_n9 NOR2X1TS
XU98 n125 FE_DBTN56_n1935 n17 XOR2X1TS
XU99 n1615 n178 n78 n380 NOR3X1TS
XU100 n1613 n1615 INVX2TS
XU101 n1610 n1612 INVX2TS
XU102 n474 n469 n468 CLKAND2X2TS
XU103 n496 n133 reset NOR2XLTS
XU104 n1655 readReady FE_DBTN50_n1929 FE_DBTN51_n1932 FE_DBTN46_n1934 NAND4XLTS
XU105 n1646 n24 n9 n20 NOR3XLTS
XU106 n1651 n1654 INVX2TS
XU107 n1644 n1646 INVX2TS
XU108 n1650 n383 n382 n267 NOR3BXLTS
XU109 n1629 FE_DBTN67_n1937 readReady FE_DBTN50_n1929 FE_DBTN46_n1934 NAND4XLTS
XU110 n1621 n24 n20 FE_DBTN73_n9 NOR3XLTS
XU111 n1626 n1628 INVX2TS
XU112 n1634 n24 n9 n10 NOR3XLTS
XU113 n1638 n1641 INVX2TS
XU114 n1637 n310 n309 n382 NOR3XLTS
XU115 n1592 n1594 INVX2TS
XU116 n1588 n1585 INVX2TS
XU117 n1591 n310 n309 n268 NOR3XLTS
XU118 n1599 n9 n20 n23 NOR3XLTS
XU119 n1598 n1599 INVX2TS
XU120 n1603 n1606 INVX2TS
XU121 n1602 n383 n268 n267 NOR3BXLTS
XU122 n1579 n1581 INVX2TS
XU123 n1568 n14 n15 n125 selectBit_WEST NAND4XLTS
XU124 n1564 n1563 INVX2TS
XU125 n1567 n127 n268 NOR2XLTS
XU126 n149 destinationAddressIn_SOUTH[11] INVX2TS
XU127 n144 destinationAddressIn_SOUTH[10] INVX2TS
XU128 n140 destinationAddressIn_SOUTH[9] INVX2TS
XU129 n153 destinationAddressIn_SOUTH[8] INVX2TS
XU130 n1950 FE_DBTN56_n1935 n496 n495 n494 AO22XLTS
XU131 n1948 n1929 n496 n495 n491 AO22XLTS
XU132 n1949 FE_DBTN67_n1937 n496 n495 n492 AO22XLTS
XU133 n1951 n133 n489 n490 OAI21XLTS
XU134 n1977 n871 n870 n869 n868 NAND4XLTS
XU135 n1976 n847 n846 n845 n844 NAND4XLTS
XU136 n1975 n835 n834 n833 n832 NAND4XLTS
XU137 n1974 n823 n822 n821 n820 NAND4XLTS
XU138 n1973 n804 n803 n802 n801 NAND4XLTS
XU139 n1972 n784 n783 n782 n781 NAND4XLTS
XU140 n1963 n654 n653 n652 n651 NAND4XLTS
XU141 n1962 n642 n641 n640 n639 NAND4XLTS
XU142 n1961 n623 n622 n621 n620 NAND4XLTS
XU143 n1960 n608 n607 n606 n605 NAND4XLTS
XU144 n1959 n597 n596 n595 n651 NAND4XLTS
XU145 n1958 n586 n585 n584 n639 NAND4XLTS
XU146 n1957 n578 n577 n576 n620 NAND4XLTS
XU147 n1956 n561 n560 n559 n605 NAND4XLTS
XU148 n1954 n540 n539 n538 n558 NAND4XLTS
XU149 n1971 n774 n773 n772 NAND3XLTS
XU150 n1970 n760 n759 n758 NAND3XLTS
XU151 n1969 n745 n744 n743 NAND3XLTS
XU152 n1968 n727 n726 n725 NAND3XLTS
XU153 n1967 n713 n712 n711 NAND3XLTS
XU154 n1966 n702 n701 n700 NAND3XLTS
XU155 n1965 n687 n686 n685 NAND3XLTS
XU156 n1964 n665 n664 n663 NAND3XLTS
XU157 n1955 n552 n551 n550 NAND3XLTS
XU158 n2021 n1108 n1107 n1106 NAND3XLTS
XU159 n2020 n1102 n1101 n1100 NAND3XLTS
XU160 n2019 n1098 n1097 n1096 NAND3XLTS
XU161 n2018 n1094 n1093 n1092 NAND3XLTS
XU162 n2017 n1085 n1084 n1083 NAND3XLTS
XU163 n2016 n1080 n1079 n1078 NAND3XLTS
XU164 n2125 n1801 n1800 n1799 NAND3XLTS
XU165 n2124 n1792 n1791 n1790 NAND3XLTS
XU166 n2123 n1785 n1784 n1783 NAND3XLTS
XU167 n2122 n1778 n1777 n1776 NAND3XLTS
XU168 n1997 n977 n976 n975 NAND3XLTS
XU169 n1996 n970 n969 n968 NAND3XLTS
XU170 n1995 n962 n961 n960 NAND3XLTS
XU171 n1994 n953 n952 n951 NAND3XLTS
XU172 n2039 n1427 n1426 n1425 NAND3XLTS
XU173 n2038 n1421 n1420 n1419 NAND3XLTS
XU174 n2037 n1417 n1416 n1415 NAND3XLTS
XU175 n2036 n1413 n1412 n1411 NAND3XLTS
XU176 n2035 n1404 n1403 n1402 NAND3XLTS
XU177 n2034 n1399 n1398 n1397 NAND3XLTS
XU178 n2045 n1457 n1456 n1455 NAND3XLTS
XU179 n2044 n1453 n1452 n1451 NAND3XLTS
XU180 n2043 n1449 n1448 n1447 NAND3XLTS
XU181 n2042 n1443 n1442 n1441 NAND3XLTS
XU182 n2041 n1436 n1435 n1434 NAND3XLTS
XU183 n2040 n1432 n1431 n1430 NAND3XLTS
XU184 n2089 n1710 n1709 n1708 NAND3XLTS
XU185 n2088 n1704 n1703 n1702 NAND3XLTS
XU186 n2087 n1697 n1696 n1695 NAND3XLTS
XU187 n2086 n1689 n1688 n1687 NAND3XLTS
XU188 n1985 n906 n905 n904 NAND3XLTS
XU189 n1984 n900 n899 n898 NAND3XLTS
XU190 n1983 n897 n896 n895 NAND3XLTS
XU191 n1982 n892 n891 n890 NAND3XLTS
XU192 n2077 n1685 n1684 n1683 NAND3XLTS
XU193 n2076 n1677 n1676 n1675 NAND3XLTS
XU194 n2075 n1669 n1668 n1667 NAND3XLTS
XU195 n2074 n1662 n1661 n1660 NAND3XLTS
XU196 n1981 n889 n888 n887 NAND3XLTS
XU197 n1980 n884 n883 n882 NAND3XLTS
XU198 n1979 n880 n879 n878 NAND3XLTS
XU199 n1978 n877 n876 n875 NAND3XLTS
XU200 n2161 n1908 n1907 n1906 NAND3XLTS
XU201 n2160 n1899 n1898 n1897 NAND3XLTS
XU202 n2159 n1887 n1886 n1885 NAND3XLTS
XU203 n2158 n1877 n1876 n1875 NAND3XLTS
XU204 n2009 n1050 n1049 n1048 NAND3XLTS
XU205 n2008 n1043 n1042 n1041 NAND3XLTS
XU206 n2007 n1038 n1037 n1036 NAND3XLTS
XU207 n2006 n1032 n1031 n1030 NAND3XLTS
XU208 n2149 n1869 n1868 n1867 NAND3XLTS
XU209 n2148 n1860 n1859 n1858 NAND3XLTS
XU210 n2147 n1848 n1847 n1846 NAND3XLTS
XU211 n2146 n1836 n1835 n1834 NAND3XLTS
XU212 n2005 n1025 n1024 n1023 NAND3XLTS
XU213 n2004 n1016 n1015 n1014 NAND3XLTS
XU214 n2003 n1009 n1008 n1007 NAND3XLTS
XU215 n2002 n1001 n1000 n999 NAND3XLTS
XU216 n2027 n1365 n1364 n1363 NAND3XLTS
XU217 n2026 n1359 n1358 n1357 NAND3XLTS
XU218 n2025 n1355 n1354 n1353 NAND3XLTS
XU219 n2024 n1351 n1350 n1349 NAND3XLTS
XU220 n2023 n1342 n1341 n1340 NAND3XLTS
XU221 n2022 n1112 n1111 n1110 NAND3XLTS
XU222 n2033 n1394 n1393 n1392 NAND3XLTS
XU223 n2032 n1389 n1388 n1387 NAND3XLTS
XU224 n2031 n1383 n1382 n1381 NAND3XLTS
XU225 n2030 n1380 n1379 n1378 NAND3XLTS
XU226 n2029 n1375 n1374 n1373 NAND3XLTS
XU227 n2028 n1369 n1368 n1367 NAND3XLTS
XU228 n2113 n1772 n1771 n1770 NAND3XLTS
XU229 n2112 n1766 n1765 n1764 NAND3XLTS
XU230 n2111 n1756 n1755 n1754 NAND3XLTS
XU231 n2110 n1748 n1747 n1746 NAND3XLTS
XU232 n1993 n947 n946 n945 NAND3XLTS
XU233 n1992 n940 n939 n938 NAND3XLTS
XU234 n1991 n935 n934 n933 NAND3XLTS
XU235 n1990 n929 n928 n927 NAND3XLTS
XU236 n2101 n1743 n1742 n1741 NAND3XLTS
XU237 n2100 n1735 n1734 n1733 NAND3XLTS
XU238 n2099 n1726 n1725 n1724 NAND3XLTS
XU239 n2098 n1717 n1716 n1715 NAND3XLTS
XU240 n1989 n922 n921 n920 NAND3XLTS
XU241 n1988 n917 n916 n915 NAND3XLTS
XU242 n1987 n914 n913 n912 NAND3XLTS
XU243 n1986 n910 n909 n908 NAND3XLTS
XU244 n2051 n1509 n1508 n1507 NAND3XLTS
XU245 n2050 n1500 n1499 n1498 NAND3XLTS
XU246 n2049 n1493 n1492 n1491 NAND3XLTS
XU247 n2048 n1485 n1484 n1483 NAND3XLTS
XU248 n2047 n1473 n1472 n1471 NAND3XLTS
XU249 n2046 n1465 n1464 n1463 NAND3XLTS
XU250 n2057 n1561 n1560 n1559 NAND3XLTS
XU251 n2056 n1552 n1551 n1550 NAND3XLTS
XU252 n2055 n1542 n1541 n1540 NAND3XLTS
XU253 n2054 n1534 n1533 n1532 NAND3XLTS
XU254 n2053 n1526 n1525 n1524 NAND3XLTS
XU255 n2052 n1518 n1517 n1516 NAND3XLTS
XU256 n2015 n1076 n1075 n1074 NAND3XLTS
XU257 n2014 n1072 n1071 n1070 NAND3XLTS
XU258 n2013 n1068 n1067 n1066 NAND3XLTS
XU259 n2012 n1065 n1064 n1063 NAND3XLTS
XU260 n2011 n1059 n1058 n1057 NAND3XLTS
XU261 n2010 n1054 n1053 n1052 NAND3XLTS
XU262 n2137 n1827 n1826 n1825 NAND3XLTS
XU263 n2136 n1820 n1819 n1818 NAND3XLTS
XU264 n2135 n1813 n1812 n1811 NAND3XLTS
XU265 n2134 n1806 n1805 n1804 NAND3XLTS
XU266 n2001 n994 n993 n992 NAND3XLTS
XU267 n2000 n988 n987 n986 NAND3XLTS
XU268 n1999 n984 n983 n982 NAND3XLTS
XU269 n1998 n980 n979 n978 NAND3XLTS
XU270 N2624 n495 n480 n1938 n502 OAI2BB2XLTS
XU271 n480 n479 FE_DBTN43_n1928 n478 n477 AOI211XLTS
XU272 n478 FE_DBTN44_n1936 n491 XOR2XLTS
XU273 n354 n316 n315 OR2X1TS
XU274 n26 n28 n23 NAND2X1TS
XU275 n1 n1588 n227 OR2X1TS
XU276 n2 n1598 n278 OR2X1TS
XU277 n3 n1644 n395 OR2X1TS
XU278 n4 n1634 n321 OR2X1TS
XU279 n5 n1575 n91 OR2X1TS
XU280 n6 n1613 n137 OR2X1TS
XU281 n7 n1599 n278 OR2X1TS
XU282 n8 n1646 n395 OR2X1TS
XU283 n422 n391 FE_DBTN71_n12 OR2X1TS
XU284 n9 n18 FE_DBTN67_n1937 n22 OA21XLTS
XU285 n10 n21 n505 OR2X1TS
XU286 n132 n26 n136 NOR2X1TS
XU287 n180 n1628 n1622 n184 NOR3XLTS
XU288 n313 n1641 n1635 n319 NOR3XLTS
XU289 n390 n1654 n1647 n394 NOR3XLTS
XU290 n11 FE_DBTN64_n133 n1629 OR2X1TS
XU291 n221 n1594 n1589 n226 NOR3XLTS
XU292 n32 n1570 n1565 n37 NOR3XLTS
XU293 n84 n1581 n1576 n89 NOR3XLTS
XU294 n12 FE_DBTN64_n133 n1655 OR2X1TS
XU295 n689 n1925 n517 NOR2XLTS
XU296 n542 n1925 n516 NOR2XLTS
XU324 n78 n15 INVX2TS
XU326 n446 selectBit_WEST INVX2TS
XU327 n1570 n1568 INVX2TS
XU331 n505 selectBit_SOUTH INVX2TS
XU332 n219 n10 INVX2TS
XU335 n22 n18 FE_DBTN67_n1937 NAND2X1TS
XU337 n20 selectBit_SOUTH n21 NAND2X1TS
XU338 n267 selectBit_SOUTH n21 n20 OAI21XLTS
XU339 n127 n309 n267 NAND2X1TS
XU341 n128 n22 INVX2TS
XU343 n23 FE_DBTN56_n1935 n22 n128 FE_DBTN46_n1934 AOI22X1TS
XU344 n24 n23 INVX2TS
XU346 n123 n26 INVX2TS
XU348 n268 selectBit_EAST n126 NAND2X1TS
XU349 n31 FE_DBTN56_n1935 n128 NAND2X1TS
XU352 n537 selectBit_NORTH selectBit_SOUTH NOR2XLTS
XU356 n522 n537 n506 NAND2X1TS
XU360 n35 n36 n31 n1563 FE_DBTN64_n133 AOI31XLTS
XU363 n37 n35 n1571 NAND2X1TS
XU364 n886 n32 INVX2TS
XU372 n55 n1568 n37 OR2X1TS
XU376 n40 FE_DBTN69_n1527 destinationAddressbuffer[7][10] FE_DBTN68_n55
+ destinationAddressIn_WEST[10] AOI22X1TS
XU380 n59 n1564 n38 OR2X1TS
XU384 n39 n51 destinationAddressIn_SOUTH[10] FE_DBTN70_n59
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU385 n2084 n886 FE_DBTN209_destinationAddressInBuffer_EAST_10_ n40 n39
+ OAI211XLTS
XU390 n43 FE_DBTN69_n1527 destinationAddressbuffer[7][8] FE_DBTN68_n55
+ destinationAddressIn_WEST[8] AOI22X1TS
XU396 n42 n51 destinationAddressIn_SOUTH[8] FE_DBTN70_n59
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU397 n2082 n886 FE_DBTN203_destinationAddressInBuffer_EAST_8_ n43 n42
+ OAI211XLTS
XU403 n48 FE_DBTN69_n1527 destinationAddressbuffer[7][11] FE_DBTN68_n55
+ destinationAddressIn_WEST[11] AOI22X1TS
XU409 n47 n51 destinationAddressIn_SOUTH[11] FE_DBTN70_n59
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU410 n2085 n886 FE_DBTN212_destinationAddressInBuffer_EAST_11_ n48 n47
+ OAI211XLTS
XU414 n53 FE_DBTN69_n1527 destinationAddressbuffer[7][9] FE_DBTN68_n55
+ destinationAddressIn_WEST[9] AOI22X1TS
XU422 n52 n51 destinationAddressIn_SOUTH[9] FE_DBTN70_n59
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU423 n2083 n886 FE_DBTN206_destinationAddressInBuffer_EAST_9_ n53 n52
+ OAI211XLTS
XU431 n61 FE_DBTN69_n1527 writeOutbuffer[7] FE_DBTN68_n55 writeIn_WEST
+ AOI22X1TS
XU433 n156 writeIn_SOUTH INVX2TS
XU436 n60 n51 writeIn_SOUTH FE_DBTN70_n59 writeIn_NORTH AOI22X1TS
XU437 n2058 n886 FE_DBTN214_writeInBuffer_EAST n61 n60 OAI211XLTS
XU440 n64 FE_DBTN69_n1527 destinationAddressbuffer[7][4] FE_DBTN68_n55
+ destinationAddressIn_WEST[4] AOI22X1TS
XU441 n162 destinationAddressIn_SOUTH[4] INVX2TS
XU443 n63 n51 destinationAddressIn_SOUTH[4] FE_DBTN70_n59
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU444 n2078 n886 FE_DBTN190_destinationAddressInBuffer_EAST_4_ n64 n63
+ OAI211XLTS
XU446 n67 FE_DBTN69_n1527 destinationAddressbuffer[7][7] FE_DBTN68_n55
+ destinationAddressIn_WEST[7] AOI22X1TS
XU447 n167 destinationAddressIn_SOUTH[7] INVX2TS
XU449 n66 n51 destinationAddressIn_SOUTH[7] FE_DBTN70_n59
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU450 n2081 n886 FE_DBTN199_destinationAddressInBuffer_EAST_7_ n67 n66
+ OAI211XLTS
XU452 n72 FE_DBTN69_n1527 destinationAddressbuffer[7][5] FE_DBTN68_n55
+ destinationAddressIn_WEST[5] AOI22X1TS
XU453 n177 destinationAddressIn_SOUTH[5] INVX2TS
XU455 n71 n51 destinationAddressIn_SOUTH[5] FE_DBTN70_n59
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU456 n2079 n886 FE_DBTN193_destinationAddressInBuffer_EAST_5_ n72 n71
+ OAI211XLTS
XU458 n76 FE_DBTN69_n1527 destinationAddressbuffer[7][6] FE_DBTN68_n55
+ destinationAddressIn_WEST[6] AOI22X1TS
XU459 n172 destinationAddressIn_SOUTH[6] INVX2TS
XU461 n75 n51 destinationAddressIn_SOUTH[6] FE_DBTN70_n59
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU462 n2080 n886 FE_DBTN196_destinationAddressInBuffer_EAST_6_ n76 n75
+ OAI211XLTS
XU463 n178 n14 INVX2TS
XU464 n266 n125 selectBit_WEST NAND2X1TS
XU465 n383 n219 FE_DBTN73_n9 n309 AOI21X1TS
XU466 n1578 n383 n268 n267 NOR3XLTS
XU468 n386 FE_DBTN47_n1933 n503 NOR2XLTS
XU470 n1575 n23 n20 FE_DBTN73_n9 NOR3XLTS
XU471 n82 FE_DBTN56_n1935 FE_DBTN67_n1937 n386 n1575 AOI31XLTS
XU472 n87 n88 n82 FE_DBTN64_n133 AOI21X1TS
XU475 n89 n87 n1582 NAND2X1TS
XU476 n1459 n84 INVX2TS
XU484 n106 n1579 n89 OR2X1TS
XU486 n95 FE_DBTN66_n1475 destinationAddressbuffer[6][11] FE_DBTN65_n106
+ destinationAddressIn_WEST[11] AOI22X1TS
XU496 n94 FE_DBTN77_n5 destinationAddressIn_NORTH[11] n92
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU497 n2097 n1459 FE_DBTN212_destinationAddressInBuffer_EAST_11_ n95 n94
+ OAI211XLTS
XU499 n97 FE_DBTN66_n1475 destinationAddressbuffer[6][8] FE_DBTN65_n106
+ destinationAddressIn_WEST[8] AOI22X1TS
XU504 n96 FE_DBTN77_n5 destinationAddressIn_NORTH[8] n92
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU505 n2094 n1459 FE_DBTN203_destinationAddressInBuffer_EAST_8_ n97 n96
+ OAI211XLTS
XU507 n100 FE_DBTN66_n1475 destinationAddressbuffer[6][9] FE_DBTN65_n106
+ destinationAddressIn_WEST[9] AOI22X1TS
XU511 n99 FE_DBTN77_n5 destinationAddressIn_NORTH[9] n92
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU512 n2095 n1459 FE_DBTN206_destinationAddressInBuffer_EAST_9_ n100 n99
+ OAI211XLTS
XU514 n105 FE_DBTN66_n1475 destinationAddressbuffer[6][10] FE_DBTN65_n106
+ destinationAddressIn_WEST[10] AOI22X1TS
XU518 n104 FE_DBTN77_n5 destinationAddressIn_NORTH[10] n92
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU519 n2096 n1459 FE_DBTN209_destinationAddressInBuffer_EAST_10_ n105 n104
+ OAI211XLTS
XU524 n109 FE_DBTN66_n1475 writeOutbuffer[6] FE_DBTN65_n106 writeIn_WEST
+ AOI22X1TS
XU529 n108 FE_DBTN77_n5 writeIn_NORTH n92 writeIn_SOUTH AOI22X1TS
XU530 n2059 n1459 FE_DBTN214_writeInBuffer_EAST n109 n108 OAI211XLTS
XU532 n112 FE_DBTN66_n1475 destinationAddressbuffer[6][5] FE_DBTN65_n106
+ destinationAddressIn_WEST[5] AOI22X1TS
XU537 n111 FE_DBTN77_n5 destinationAddressIn_NORTH[5] n92
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU538 n2091 n1459 FE_DBTN193_destinationAddressInBuffer_EAST_5_ n112 n111
+ OAI211XLTS
XU539 n114 FE_DBTN66_n1475 destinationAddressbuffer[6][4] FE_DBTN65_n106
+ destinationAddressIn_WEST[4] AOI22X1TS
XU543 n113 FE_DBTN77_n5 destinationAddressIn_NORTH[4] n92
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU544 n2090 n1459 FE_DBTN190_destinationAddressInBuffer_EAST_4_ n114 n113
+ OAI211XLTS
XU545 n117 FE_DBTN66_n1475 destinationAddressbuffer[6][7] FE_DBTN65_n106
+ destinationAddressIn_WEST[7] AOI22X1TS
XU549 n116 FE_DBTN77_n5 destinationAddressIn_NORTH[7] n92
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU550 n2093 n1459 FE_DBTN199_destinationAddressInBuffer_EAST_7_ n117 n116
+ OAI211XLTS
XU551 n121 FE_DBTN66_n1475 destinationAddressbuffer[6][6] FE_DBTN65_n106
+ destinationAddressIn_WEST[6] AOI22X1TS
XU555 n120 FE_DBTN77_n5 destinationAddressIn_NORTH[6] n92
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU556 n2092 n1459 FE_DBTN196_destinationAddressInBuffer_EAST_6_ n121 n120
+ OAI211XLTS
XU559 n129 n128 FE_DBTN46_n1934 NAND2X1TS
XU561 n135 n131 n26 n129 FE_DBTN64_n133 AOI31XLTS
XU563 n136 n137 n131 NAND2BX1TS
XU564 n965 n132 INVX2TS
XU572 n141 n1615 n1610 n137 NOR3XLTS
XU575 n139 FE_DBTN63_n1377 destinationAddressbuffer[3][9] n141
+ destinationAddressIn_EAST[9] AOI22X1TS
XU576 n163 n123 n136 OR2X1TS
XU584 n138 FE_DBTN62_n163 destinationAddressIn_NORTH[9] FE_DBTN76_n6
+ destinationAddressIn_WEST[9] AOI22X1TS
XU585 n2131 n965 n140 n139 n138 OAI211XLTS
XU589 n143 FE_DBTN63_n1377 destinationAddressbuffer[3][10] n141
+ destinationAddressIn_EAST[10] AOI22X1TS
XU593 n142 FE_DBTN62_n163 destinationAddressIn_NORTH[10] FE_DBTN76_n6
+ destinationAddressIn_WEST[10] AOI22X1TS
XU594 n2132 n965 n144 n143 n142 OAI211XLTS
XU596 n148 FE_DBTN63_n1377 destinationAddressbuffer[3][11] n141
+ destinationAddressIn_EAST[11] AOI22X1TS
XU599 n147 FE_DBTN62_n163 destinationAddressIn_NORTH[11] FE_DBTN76_n6
+ destinationAddressIn_WEST[11] AOI22X1TS
XU600 n2133 n965 n149 n148 n147 OAI211XLTS
XU601 n152 FE_DBTN63_n1377 destinationAddressbuffer[3][8] n141
+ destinationAddressIn_EAST[8] AOI22X1TS
XU604 n151 FE_DBTN62_n163 destinationAddressIn_NORTH[8] FE_DBTN76_n6
+ destinationAddressIn_WEST[8] AOI22X1TS
XU605 n2130 n965 n153 n152 n151 OAI211XLTS
XU608 n155 FE_DBTN63_n1377 writeOutbuffer[3] n141 writeIn_EAST AOI22X1TS
XU611 n154 FE_DBTN62_n163 writeIn_NORTH FE_DBTN76_n6 writeIn_WEST AOI22X1TS
XU612 n2062 n965 n156 n155 n154 OAI211XLTS
XU615 n161 FE_DBTN63_n1377 destinationAddressbuffer[3][4] n141
+ destinationAddressIn_EAST[4] AOI22X1TS
XU619 n160 FE_DBTN62_n163 destinationAddressIn_NORTH[4] FE_DBTN76_n6
+ destinationAddressIn_WEST[4] AOI22X1TS
XU620 n2126 n965 n162 n161 n160 OAI211XLTS
XU621 n166 FE_DBTN63_n1377 destinationAddressbuffer[3][7] n141
+ destinationAddressIn_EAST[7] AOI22X1TS
XU625 n165 FE_DBTN62_n163 destinationAddressIn_NORTH[7] FE_DBTN76_n6
+ destinationAddressIn_WEST[7] AOI22X1TS
XU626 n2129 n965 n167 n166 n165 OAI211XLTS
XU627 n171 FE_DBTN63_n1377 destinationAddressbuffer[3][6] n141
+ destinationAddressIn_EAST[6] AOI22X1TS
XU630 n170 FE_DBTN62_n163 destinationAddressIn_NORTH[6] FE_DBTN76_n6
+ destinationAddressIn_WEST[6] AOI22X1TS
XU631 n2128 n965 n172 n171 n170 OAI211XLTS
XU632 n176 FE_DBTN63_n1377 destinationAddressbuffer[3][5] n141
+ destinationAddressIn_EAST[5] AOI22X1TS
XU635 n175 FE_DBTN62_n163 destinationAddressIn_NORTH[5] FE_DBTN76_n6
+ destinationAddressIn_WEST[5] AOI22X1TS
XU636 n2127 n965 n177 n176 n175 OAI211XLTS
XU637 n310 n267 INVX2TS
XU639 n1625 n383 n267 n382 NOR3XLTS
XU640 n179 FE_DBTN67_n1937 n386 FE_DBTN46_n1934 n1621 AOI31XLTS
XU641 n181 n183 n179 FE_DBTN64_n133 AOI21X1TS
XU642 n184 n181 n1629 NAND2X1TS
XU643 n1344 n180 INVX2TS
XU649 n197 n1626 n184 OR2X1TS
XU653 n188 FE_DBTN60_n1343 destinationAddressbuffer[2][8] FE_DBTN61_n197
+ destinationAddressIn_WEST[8] AOI22X1TS
XU658 n187 n199 destinationAddressIn_NORTH[8] n186
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU659 n2142 n1344 FE_DBTN203_destinationAddressInBuffer_EAST_8_ n188 n187
+ OAI211XLTS
XU661 n192 FE_DBTN60_n1343 destinationAddressbuffer[2][11] FE_DBTN61_n197
+ destinationAddressIn_WEST[11] AOI22X1TS
XU667 n191 n199 destinationAddressIn_NORTH[11] n186
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU668 n2145 n1344 FE_DBTN212_destinationAddressInBuffer_EAST_11_ n192 n191
+ OAI211XLTS
XU671 n196 FE_DBTN60_n1343 destinationAddressbuffer[2][10] FE_DBTN61_n197
+ destinationAddressIn_WEST[10] AOI22X1TS
XU673 n195 n199 destinationAddressIn_NORTH[10] n186
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU674 n2144 n1344 FE_DBTN209_destinationAddressInBuffer_EAST_10_ n196 n195
+ OAI211XLTS
XU676 n202 FE_DBTN60_n1343 destinationAddressbuffer[2][9] FE_DBTN61_n197
+ destinationAddressIn_WEST[9] AOI22X1TS
XU680 n201 n199 destinationAddressIn_NORTH[9] n186
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU681 n2143 n1344 FE_DBTN206_destinationAddressInBuffer_EAST_9_ n202 n201
+ OAI211XLTS
XU683 n204 FE_DBTN60_n1343 writeOutbuffer[2] FE_DBTN61_n197 writeIn_WEST
+ AOI22X1TS
XU684 n203 n199 writeIn_NORTH n186 writeIn_SOUTH AOI22X1TS
XU685 n2063 n1344 FE_DBTN214_writeInBuffer_EAST n204 n203 OAI211XLTS
XU687 n207 FE_DBTN60_n1343 destinationAddressbuffer[2][5] FE_DBTN61_n197
+ destinationAddressIn_WEST[5] AOI22X1TS
XU688 n206 n199 destinationAddressIn_NORTH[5] n186
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU689 n2139 n1344 FE_DBTN193_destinationAddressInBuffer_EAST_5_ n207 n206
+ OAI211XLTS
XU690 n209 FE_DBTN60_n1343 destinationAddressbuffer[2][7] FE_DBTN61_n197
+ destinationAddressIn_WEST[7] AOI22X1TS
XU691 n208 n199 destinationAddressIn_NORTH[7] n186
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU692 n2141 n1344 FE_DBTN199_destinationAddressInBuffer_EAST_7_ n209 n208
+ OAI211XLTS
XU693 n213 FE_DBTN60_n1343 destinationAddressbuffer[2][6] FE_DBTN61_n197
+ destinationAddressIn_WEST[6] AOI22X1TS
XU694 n212 n199 destinationAddressIn_NORTH[6] n186
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU695 n2140 n1344 FE_DBTN196_destinationAddressInBuffer_EAST_6_ n213 n212
+ OAI211XLTS
XU696 n217 FE_DBTN60_n1343 destinationAddressbuffer[2][4] FE_DBTN61_n197
+ destinationAddressIn_WEST[4] AOI22X1TS
XU697 n216 n199 destinationAddressIn_NORTH[4] n186
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU698 n2138 n1344 FE_DBTN190_destinationAddressInBuffer_EAST_4_ n217 n216
+ OAI211XLTS
XU699 n1589 n1591 CLKINVX1TS
XU701 n223 n225 n1585 n220 FE_DBTN64_n133 AOI31XLTS
XU703 n226 n223 n1595 NAND2X1TS
XU704 n1428 n221 INVX2TS
XU711 n239 n1592 n226 OR2X1TS
XU715 n230 FE_DBTN57_n1438 destinationAddressbuffer[5][8] FE_DBTN59_n239
+ destinationAddressIn_WEST[8] AOI22X1TS
XU717 n245 n1585 n227 OR2X1TS
XU721 n229 FE_DBTN81_n1 destinationAddressIn_NORTH[8] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU722 n2106 n1428 FE_DBTN203_destinationAddressInBuffer_EAST_8_ n230 n229
+ OAI211XLTS
XU724 n233 FE_DBTN57_n1438 destinationAddressbuffer[5][10] FE_DBTN59_n239
+ destinationAddressIn_WEST[10] AOI22X1TS
XU726 n232 FE_DBTN81_n1 destinationAddressIn_NORTH[10] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU727 n2108 n1428 FE_DBTN209_destinationAddressInBuffer_EAST_10_ n233 n232
+ OAI211XLTS
XU730 n237 FE_DBTN57_n1438 destinationAddressbuffer[5][9] FE_DBTN59_n239
+ destinationAddressIn_WEST[9] AOI22X1TS
XU735 n236 FE_DBTN81_n1 destinationAddressIn_NORTH[9] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU736 n2107 n1428 FE_DBTN206_destinationAddressInBuffer_EAST_9_ n237 n236
+ OAI211XLTS
XU738 n243 FE_DBTN57_n1438 destinationAddressbuffer[5][11] FE_DBTN59_n239
+ destinationAddressIn_WEST[11] AOI22X1TS
XU739 n242 FE_DBTN81_n1 destinationAddressIn_NORTH[11] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU740 n2109 n1428 FE_DBTN212_destinationAddressInBuffer_EAST_11_ n243 n242
+ OAI211XLTS
XU742 n248 FE_DBTN57_n1438 writeOutbuffer[5] FE_DBTN59_n239 writeIn_WEST
+ AOI22X1TS
XU744 n247 FE_DBTN81_n1 writeIn_NORTH FE_DBTN58_n245 writeIn_SOUTH AOI22X1TS
XU745 n2060 n1428 FE_DBTN214_writeInBuffer_EAST n248 n247 OAI211XLTS
XU747 n251 FE_DBTN57_n1438 destinationAddressbuffer[5][6] FE_DBTN59_n239
+ destinationAddressIn_WEST[6] AOI22X1TS
XU748 n250 FE_DBTN81_n1 destinationAddressIn_NORTH[6] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU749 n2104 n1428 FE_DBTN196_destinationAddressInBuffer_EAST_6_ n251 n250
+ OAI211XLTS
XU750 n254 FE_DBTN57_n1438 destinationAddressbuffer[5][7] FE_DBTN59_n239
+ destinationAddressIn_WEST[7] AOI22X1TS
XU752 n253 FE_DBTN81_n1 destinationAddressIn_NORTH[7] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU753 n2105 n1428 FE_DBTN199_destinationAddressInBuffer_EAST_7_ n254 n253
+ OAI211XLTS
XU754 n258 FE_DBTN57_n1438 destinationAddressbuffer[5][5] FE_DBTN59_n239
+ destinationAddressIn_WEST[5] AOI22X1TS
XU755 n257 FE_DBTN81_n1 destinationAddressIn_NORTH[5] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU756 n2103 n1428 FE_DBTN193_destinationAddressInBuffer_EAST_5_ n258 n257
+ OAI211XLTS
XU757 n263 FE_DBTN57_n1438 destinationAddressbuffer[5][4] FE_DBTN59_n239
+ destinationAddressIn_WEST[4] AOI22X1TS
XU759 n262 FE_DBTN81_n1 destinationAddressIn_NORTH[4] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU760 n2102 n1428 FE_DBTN190_destinationAddressInBuffer_EAST_4_ n263 n262
+ OAI211XLTS
XU761 n270 FE_DBTN56_n1935 n386 FE_DBTN51_n1932 n1599 AOI31XLTS
XU762 n275 n276 n270 FE_DBTN64_n133 AOI21X1TS
XU763 n277 n275 n1607 NAND2X1TS
XU764 n1395 n272 INVX2TS
XU771 n289 n1603 n277 OR2X1TS
XU773 n281 FE_DBTN54_n1406 destinationAddressbuffer[4][10] FE_DBTN55_n289
+ destinationAddressIn_WEST[10] AOI22X1TS
XU777 n280 FE_DBTN80_n2 destinationAddressIn_SOUTH[10] FE_DBTN75_n7
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU778 n2120 n1395 FE_DBTN209_destinationAddressInBuffer_EAST_10_ n281 n280
+ OAI211XLTS
XU782 n284 FE_DBTN54_n1406 destinationAddressbuffer[4][8] FE_DBTN55_n289
+ destinationAddressIn_WEST[8] AOI22X1TS
XU785 n283 FE_DBTN80_n2 destinationAddressIn_SOUTH[8] FE_DBTN75_n7
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU786 n2118 n1395 FE_DBTN203_destinationAddressInBuffer_EAST_8_ n284 n283
+ OAI211XLTS
XU789 n288 FE_DBTN54_n1406 destinationAddressbuffer[4][9] FE_DBTN55_n289
+ destinationAddressIn_WEST[9] AOI22X1TS
XU794 n287 FE_DBTN80_n2 destinationAddressIn_SOUTH[9] FE_DBTN75_n7
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU795 n2119 n1395 FE_DBTN206_destinationAddressInBuffer_EAST_9_ n288 n287
+ OAI211XLTS
XU797 n293 FE_DBTN54_n1406 destinationAddressbuffer[4][11] FE_DBTN55_n289
+ destinationAddressIn_WEST[11] AOI22X1TS
XU800 n292 FE_DBTN80_n2 destinationAddressIn_SOUTH[11] FE_DBTN75_n7
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU801 n2121 n1395 FE_DBTN212_destinationAddressInBuffer_EAST_11_ n293 n292
+ OAI211XLTS
XU803 n295 FE_DBTN54_n1406 writeOutbuffer[4] FE_DBTN55_n289 writeIn_WEST
+ AOI22X1TS
XU805 n294 FE_DBTN80_n2 writeIn_SOUTH FE_DBTN75_n7 writeIn_NORTH AOI22X1TS
XU806 n2061 n1395 FE_DBTN214_writeInBuffer_EAST n295 n294 OAI211XLTS
XU808 n298 FE_DBTN54_n1406 destinationAddressbuffer[4][4] FE_DBTN55_n289
+ destinationAddressIn_WEST[4] AOI22X1TS
XU809 n297 FE_DBTN80_n2 destinationAddressIn_SOUTH[4] FE_DBTN75_n7
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU810 n2114 n1395 FE_DBTN190_destinationAddressInBuffer_EAST_4_ n298 n297
+ OAI211XLTS
XU811 n301 FE_DBTN54_n1406 destinationAddressbuffer[4][5] FE_DBTN55_n289
+ destinationAddressIn_WEST[5] AOI22X1TS
XU813 n300 FE_DBTN80_n2 destinationAddressIn_SOUTH[5] FE_DBTN75_n7
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU814 n2115 n1395 FE_DBTN193_destinationAddressInBuffer_EAST_5_ n301 n300
+ OAI211XLTS
XU815 n304 FE_DBTN54_n1406 destinationAddressbuffer[4][6] FE_DBTN55_n289
+ destinationAddressIn_WEST[6] AOI22X1TS
XU817 n303 FE_DBTN80_n2 destinationAddressIn_SOUTH[6] FE_DBTN75_n7
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU818 n2116 n1395 FE_DBTN196_destinationAddressInBuffer_EAST_6_ n304 n303
+ OAI211XLTS
XU819 n307 FE_DBTN54_n1406 destinationAddressbuffer[4][7] FE_DBTN55_n289
+ destinationAddressIn_WEST[7] AOI22X1TS
XU820 n306 FE_DBTN80_n2 destinationAddressIn_SOUTH[7] FE_DBTN75_n7
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU821 n2117 n1395 FE_DBTN199_destinationAddressInBuffer_EAST_7_ n307 n306
+ OAI211XLTS
XU822 n312 n18 FE_DBTN51_n1932 FE_DBTN46_n1934 n1634 AOI31XLTS
XU823 n316 n318 n312 FE_DBTN64_n133 AOI21X1TS
XU824 n319 n316 n1642 NAND2X1TS
XU825 n1088 n313 INVX2TS
XU832 n341 n1638 n319 OR2X1TS
XU834 n327 FE_DBTN52_n354 destinationAddressbuffer[1][11] FE_DBTN53_n341
+ destinationAddressIn_WEST[11] AOI22X1TS
XU842 n326 FE_DBTN78_n4 destinationAddressIn_NORTH[11] n322
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU843 n2157 n1088 FE_DBTN212_destinationAddressInBuffer_EAST_11_ n327 n326
+ OAI211XLTS
XU848 n333 FE_DBTN52_n354 destinationAddressbuffer[1][8] FE_DBTN53_n341
+ destinationAddressIn_WEST[8] AOI22X1TS
XU851 n332 FE_DBTN78_n4 destinationAddressIn_NORTH[8] n322
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU852 n2154 n1088 FE_DBTN203_destinationAddressInBuffer_EAST_8_ n333 n332
+ OAI211XLTS
XU855 n340 FE_DBTN52_n354 destinationAddressbuffer[1][10] FE_DBTN53_n341
+ destinationAddressIn_WEST[10] AOI22X1TS
XU857 n339 FE_DBTN78_n4 destinationAddressIn_NORTH[10] n322
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU858 n2156 n1088 FE_DBTN209_destinationAddressInBuffer_EAST_10_ n340 n339
+ OAI211XLTS
XU860 n348 FE_DBTN52_n354 destinationAddressbuffer[1][9] FE_DBTN53_n341
+ destinationAddressIn_WEST[9] AOI22X1TS
XU862 n347 FE_DBTN78_n4 destinationAddressIn_NORTH[9] n322
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU863 n2155 n1088 FE_DBTN206_destinationAddressInBuffer_EAST_9_ n348 n347
+ OAI211XLTS
XU865 n353 FE_DBTN52_n354 writeOutbuffer[1] FE_DBTN53_n341 writeIn_WEST
+ AOI22X1TS
XU867 n352 FE_DBTN78_n4 writeIn_NORTH n322 writeIn_SOUTH AOI22X1TS
XU868 n2064 n1088 FE_DBTN214_writeInBuffer_EAST n353 n352 OAI211XLTS
XU870 n359 FE_DBTN52_n354 destinationAddressbuffer[1][7] FE_DBTN53_n341
+ destinationAddressIn_WEST[7] AOI22X1TS
XU872 n358 FE_DBTN78_n4 destinationAddressIn_NORTH[7] n322
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU873 n2153 n1088 FE_DBTN199_destinationAddressInBuffer_EAST_7_ n359 n358
+ OAI211XLTS
XU874 n365 FE_DBTN52_n354 destinationAddressbuffer[1][6] FE_DBTN53_n341
+ destinationAddressIn_WEST[6] AOI22X1TS
XU875 n364 FE_DBTN78_n4 destinationAddressIn_NORTH[6] n322
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU876 n2152 n1088 FE_DBTN196_destinationAddressInBuffer_EAST_6_ n365 n364
+ OAI211XLTS
XU877 n371 FE_DBTN52_n354 destinationAddressbuffer[1][4] FE_DBTN53_n341
+ destinationAddressIn_WEST[4] AOI22X1TS
XU878 n370 FE_DBTN78_n4 destinationAddressIn_NORTH[4] n322
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU879 n2150 n1088 FE_DBTN190_destinationAddressInBuffer_EAST_4_ n371 n370
+ OAI211XLTS
XU880 n378 FE_DBTN52_n354 destinationAddressbuffer[1][5] FE_DBTN53_n341
+ destinationAddressIn_WEST[5] AOI22X1TS
XU881 n377 FE_DBTN78_n4 destinationAddressIn_NORTH[5] n322
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU882 n2151 n1088 FE_DBTN193_destinationAddressInBuffer_EAST_5_ n378 n377
+ OAI211XLTS
XU883 n1654 n14 n15 n380 NOR3X1TS
XU884 n387 n386 FE_DBTN51_n1932 FE_DBTN46_n1934 n1646 AOI31XLTS
XU885 n391 n393 n387 FE_DBTN64_n133 AOI21X1TS
XU886 n394 n391 n1655 NAND2X1TS
XU887 n1061 n390 INVX2TS
XU893 n416 n1651 n394 OR2X1TS
XU895 n398 FE_DBTN49_n422 destinationAddressbuffer[0][8] FE_DBTN48_n416
+ destinationAddressIn_WEST[8] AOI22X1TS
XU898 n397 FE_DBTN79_n3 destinationAddressIn_SOUTH[8] FE_DBTN74_n8
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU899 n2166 n1061 FE_DBTN203_destinationAddressInBuffer_EAST_8_ n398 n397
+ OAI211XLTS
XU902 n403 FE_DBTN49_n422 destinationAddressbuffer[0][9] FE_DBTN48_n416
+ destinationAddressIn_WEST[9] AOI22X1TS
XU907 n402 FE_DBTN79_n3 destinationAddressIn_SOUTH[9] FE_DBTN74_n8
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU908 n2167 n1061 FE_DBTN206_destinationAddressInBuffer_EAST_9_ n403 n402
+ OAI211XLTS
XU909 n409 FE_DBTN49_n422 destinationAddressbuffer[0][11] FE_DBTN48_n416
+ destinationAddressIn_WEST[11] AOI22X1TS
XU914 n408 FE_DBTN79_n3 destinationAddressIn_SOUTH[11] FE_DBTN74_n8
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU915 n2169 n1061 FE_DBTN212_destinationAddressInBuffer_EAST_11_ n409 n408
+ OAI211XLTS
XU917 n415 FE_DBTN49_n422 destinationAddressbuffer[0][10] FE_DBTN48_n416
+ destinationAddressIn_WEST[10] AOI22X1TS
XU918 n414 FE_DBTN79_n3 destinationAddressIn_SOUTH[10] FE_DBTN74_n8
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU919 n2168 n1061 FE_DBTN209_destinationAddressInBuffer_EAST_10_ n415 n414
+ OAI211XLTS
XU924 n421 FE_DBTN49_n422 writeOutbuffer[0] FE_DBTN48_n416 writeIn_WEST
+ AOI22X1TS
XU926 n420 FE_DBTN79_n3 writeIn_SOUTH FE_DBTN74_n8 writeIn_NORTH AOI22X1TS
XU927 n2065 n1061 FE_DBTN214_writeInBuffer_EAST n421 n420 OAI211XLTS
XU930 n427 FE_DBTN49_n422 destinationAddressbuffer[0][5] FE_DBTN48_n416
+ destinationAddressIn_WEST[5] AOI22X1TS
XU931 n426 FE_DBTN79_n3 destinationAddressIn_SOUTH[5] FE_DBTN74_n8
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU932 n2163 n1061 FE_DBTN193_destinationAddressInBuffer_EAST_5_ n427 n426
+ OAI211XLTS
XU933 n430 FE_DBTN49_n422 destinationAddressbuffer[0][7] FE_DBTN48_n416
+ destinationAddressIn_WEST[7] AOI22X1TS
XU934 n429 FE_DBTN79_n3 destinationAddressIn_SOUTH[7] FE_DBTN74_n8
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU935 n2165 n1061 FE_DBTN199_destinationAddressInBuffer_EAST_7_ n430 n429
+ OAI211XLTS
XU936 n434 FE_DBTN49_n422 destinationAddressbuffer[0][6] FE_DBTN48_n416
+ destinationAddressIn_WEST[6] AOI22X1TS
XU938 n433 FE_DBTN79_n3 destinationAddressIn_SOUTH[6] FE_DBTN74_n8
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU939 n2164 n1061 FE_DBTN196_destinationAddressInBuffer_EAST_6_ n434 n433
+ OAI211XLTS
XU940 n439 FE_DBTN49_n422 destinationAddressbuffer[0][4] FE_DBTN48_n416
+ destinationAddressIn_WEST[4] AOI22X1TS
XU941 n438 FE_DBTN79_n3 destinationAddressIn_SOUTH[4] FE_DBTN74_n8
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU942 n2162 n1061 FE_DBTN190_destinationAddressInBuffer_EAST_4_ n439 n438
+ OAI211XLTS
XU943 n490 reset INVX2TS
XU944 n502 n490 n1926 NAND2X1TS
XU945 n495 reset FE_DBTN64_n133 NOR2XLTS
XU946 n529 n1930 INVX2TS
XU948 n441 n1924 INVX2TS
XU949 n455 FE_DBTN47_n1933 n441 NAND2X1TS
XU953 n447 FE_DBTN56_n1935 FE_DBTN42_n1927 FE_DBTN43_n1928 FE_DBTN46_n1934
+ AOI22X1TS
XU955 n463 n466 INVX2TS
XU957 n462 FE_DBTN44_n1936 FE_DBTN50_n1929 n448 AOI21X1TS
XU958 n466 n468 n454 n453 ADDHX1TS
XU959 n457 n468 INVX2TS
XU960 n487 FE_DBTN47_n1933 n1936 n455 OAI21XLTS
XU961 n460 n458 n457 n487 AOI21X1TS
XU962 n459 n458 n457 n464 n463 OAI22X1TS
XU963 n461 n467 n460 n459 AOI21X1TS
XU964 n465 n464 n463 n462 n461 AOI211X1TS
XU965 n469 n465 INVX2TS
XU966 n472 n469 n466 NAND2X1TS
XU967 n471 n1934 n470 XNOR2X1TS
XU968 n494 n472 n471 XOR2X1TS
XU969 n479 n494 INVX2TS
XU972 n475 n491 FE_DBTN47_n1933 n473 ADDHXLTS
XU973 n476 n1931 n492 XNOR2X1TS
XU974 n477 n479 FE_DBTN43_n1928 n476 OAI21X1TS
XU975 n527 FE_DBTN44_n1936 n529 NAND2X1TS
XU976 n501 FE_DBTN44_n1936 n1931 n527 OAI21XLTS
XU978 n836 n527 FE_DBTN42_n1927 NOR2XLTS
XU981 n498 n527 FE_DBTN42_n1927 n836 AOI21X1TS
XU982 n484 FE_DBTN67_n1937 n501 FE_DBTN46_n1934 n498 OAI22X1TS
XU983 n488 n501 FE_DBTN67_n1937 FE_DBTN46_n1934 n498 n484 AOI221XLTS
XU984 n489 n488 n487 n1926 AOI21X1TS
XU985 n500 n490 n1925 NAND2X1TS
XU986 n1947 n1924 n502 n500 n441 AOI22X1TS
XU987 n499 n498 INVX2TS
XU988 n1952 FE_DBTN42_n1927 n502 n499 n500 OAI22X1TS
XU989 n1953 n1930 n502 n501 n500 OAI22X1TS
XU996 n519 n1925 INVX2TS
XU997 n507 n537 n519 NAND2X1TS
XU998 n610 readReady selectBit_EAST n446 n507 NOR4XLTS
XU1002 n540 readIn_SOUTH n542 readIn_WEST n610 AOI22X1TS
XU1007 n643 selectBit_WEST readReady n511 n507 NOR4XLTS
XU1011 n539 readIn_NORTH n689 readIn_EAST n643 AOI22X1TS
XU1012 n515 selectBit_EAST readReady n446 NOR3XLTS
XU1013 n514 selectBit_WEST readReady n511 NOR3XLTS
XU1014 n672 n519 n518 n517 n516 NAND4XLTS
XU1019 n717 FE_DBTN44_n1936 FE_DBTN43_n1928 n1930 NOR3XLTS
XU1022 n691 FE_DBTN44_n1936 n1931 FE_DBTN43_n1928 NOR3XLTS
XU1025 n534 readOutbuffer[2] n717 readOutbuffer[0] n691 AOI22X1TS
XU1026 n718 FE_DBTN44_n1936 n1930 FE_DBTN42_n1927 NOR3XLTS
XU1029 n692 FE_DBTN44_n1936 n529 FE_DBTN42_n1927 NOR3XLTS
XU1032 n533 readOutbuffer[6] n718 readOutbuffer[4] n692 AOI22X1TS
XU1033 n719 FE_DBTN43_n1928 n527 NOR2XLTS
XU1036 n693 n529 FE_DBTN43_n1928 n1936 NOR3XLTS
XU1039 n532 readOutbuffer[3] n719 readOutbuffer[1] n693 AOI22X1TS
XU1041 n859 n1931 n441 FE_DBTN42_n1927 NOR3XLTS
XU1044 n531 readOutbuffer[7] n836 readOutbuffer[5] n859 AOI22X1TS
XU1045 n535 n534 n533 n532 n531 NAND4XLTS
XU1046 n538 readOut n549 n1925 n535 AOI22X1TS
XU1048 n552 writeIn_EAST n643 writeIn_WEST n610 AOI22X1TS
XU1051 n551 writeIn_NORTH n689 writeIn_SOUTH n542 AOI22X1TS
XU1052 n547 writeOutbuffer[2] n717 writeOutbuffer[0] n691 AOI22X1TS
XU1053 n546 writeOutbuffer[6] n718 writeOutbuffer[4] n692 AOI22X1TS
XU1054 n545 writeOutbuffer[3] n719 writeOutbuffer[1] n693 AOI22X1TS
XU1055 n544 writeOutbuffer[7] n836 writeOutbuffer[5] n859 AOI22X1TS
XU1056 n548 n547 n546 n545 n544 NAND4XLTS
XU1057 n550 writeOut n549 n1925 n548 AOI22X1TS
XU1062 n561 requesterAddressIn_NORTH[0] n689 requesterAddressIn_EAST[0] n643
+ AOI22X1TS
XU1067 n560 requesterAddressIn_SOUTH[0] n542 requesterAddressIn_WEST[0] n610
+ AOI22X1TS
XU1070 n556 requesterAddressbuffer[2][0] n717 requesterAddressbuffer[0][0] n691
+ AOI22X1TS
XU1071 n555 requesterAddressbuffer[6][0] n718 requesterAddressbuffer[4][0] n692
+ AOI22X1TS
XU1072 n554 requesterAddressbuffer[3][0] n719 requesterAddressbuffer[1][0] n693
+ AOI22X1TS
XU1075 n553 requesterAddressbuffer[7][0] n836 requesterAddressbuffer[5][0] n859
+ AOI22X1TS
XU1076 n557 n556 n555 n554 n553 NAND4XLTS
XU1077 n559 requesterAddressOut[0] FE_DBTN45_n672 n1925 n557 AOI22X1TS
XU1081 n605 readRequesterAddress[0] FE_DBTN41_n558 NAND2X1TS
XU1085 n578 requesterAddressIn_NORTH[1] n689 requesterAddressIn_EAST[1] n643
+ AOI22X1TS
XU1090 n577 requesterAddressIn_SOUTH[1] n542 requesterAddressIn_WEST[1] n610
+ AOI22X1TS
XU1091 n574 requesterAddressbuffer[2][1] n717 requesterAddressbuffer[0][1] n691
+ AOI22X1TS
XU1092 n573 requesterAddressbuffer[6][1] n718 requesterAddressbuffer[4][1] n692
+ AOI22X1TS
XU1093 n572 requesterAddressbuffer[3][1] n719 requesterAddressbuffer[1][1] n693
+ AOI22X1TS
XU1094 n571 requesterAddressbuffer[7][1] n836 requesterAddressbuffer[5][1] n859
+ AOI22X1TS
XU1095 n575 n574 n573 n572 n571 NAND4XLTS
XU1096 n576 requesterAddressOut[1] FE_DBTN45_n672 n1925 n575 AOI22X1TS
XU1099 n620 readRequesterAddress[1] FE_DBTN41_n558 NAND2X1TS
XU1104 n586 requesterAddressIn_NORTH[2] n689 requesterAddressIn_EAST[2] n643
+ AOI22X1TS
XU1108 n585 requesterAddressIn_SOUTH[2] n542 requesterAddressIn_WEST[2] n610
+ AOI22X1TS
XU1111 n582 requesterAddressbuffer[2][2] n717 requesterAddressbuffer[0][2] n691
+ AOI22X1TS
XU1113 n581 requesterAddressbuffer[6][2] n718 requesterAddressbuffer[4][2] n692
+ AOI22X1TS
XU1115 n580 requesterAddressbuffer[3][2] n719 requesterAddressbuffer[1][2] n693
+ AOI22X1TS
XU1117 n579 requesterAddressbuffer[7][2] n836 requesterAddressbuffer[5][2] n859
+ AOI22X1TS
XU1118 n583 n582 n581 n580 n579 NAND4XLTS
XU1119 n584 requesterAddressOut[2] FE_DBTN45_n672 n1925 n583 AOI22X1TS
XU1122 n639 readRequesterAddress[2] FE_DBTN41_n558 NAND2X1TS
XU1126 n597 requesterAddressIn_NORTH[3] n689 requesterAddressIn_EAST[3] n643
+ AOI22X1TS
XU1130 n596 requesterAddressIn_SOUTH[3] n542 requesterAddressIn_WEST[3] n610
+ AOI22X1TS
XU1131 n591 requesterAddressbuffer[2][3] n717 requesterAddressbuffer[0][3] n691
+ AOI22X1TS
XU1132 n590 requesterAddressbuffer[6][3] n718 requesterAddressbuffer[4][3] n692
+ AOI22X1TS
XU1133 n589 requesterAddressbuffer[3][3] n719 requesterAddressbuffer[1][3] n693
+ AOI22X1TS
XU1135 n588 requesterAddressbuffer[7][3] n836 requesterAddressbuffer[5][3] n859
+ AOI22X1TS
XU1136 n592 n591 n590 n589 n588 NAND4XLTS
XU1137 n595 requesterAddressOut[3] FE_DBTN45_n672 n1925 n592 AOI22X1TS
XU1140 n651 readRequesterAddress[3] FE_DBTN41_n558 NAND2X1TS
XU1143 n608 destinationAddressIn_NORTH[0] n689 destinationAddressIn_EAST[0]
+ n643 AOI22X1TS
XU1146 n607 destinationAddressIn_SOUTH[0] n542 destinationAddressIn_WEST[0]
+ n610 AOI22X1TS
XU1148 n603 destinationAddressbuffer[2][0] n717 destinationAddressbuffer[0][0]
+ n691 AOI22X1TS
XU1149 n602 destinationAddressbuffer[6][0] n718 destinationAddressbuffer[4][0]
+ n692 AOI22X1TS
XU1150 n601 destinationAddressbuffer[3][0] n719 destinationAddressbuffer[1][0]
+ n693 AOI22X1TS
XU1151 n600 destinationAddressbuffer[7][0] n836 destinationAddressbuffer[5][0]
+ n859 AOI22X1TS
XU1152 n604 n603 n602 n601 n600 NAND4XLTS
XU1153 n606 destinationAddressOut[0] FE_DBTN45_n672 n1925 n604 AOI22X1TS
XU1156 n623 destinationAddressIn_NORTH[1] n689 destinationAddressIn_EAST[1]
+ n643 AOI22X1TS
XU1159 n622 destinationAddressIn_SOUTH[1] n542 destinationAddressIn_WEST[1]
+ n610 AOI22X1TS
XU1160 n618 destinationAddressbuffer[2][1] n717 destinationAddressbuffer[0][1]
+ n691 AOI22X1TS
XU1161 n617 destinationAddressbuffer[6][1] n718 destinationAddressbuffer[4][1]
+ n692 AOI22X1TS
XU1162 n616 destinationAddressbuffer[3][1] n719 destinationAddressbuffer[1][1]
+ n693 AOI22X1TS
XU1163 n615 destinationAddressbuffer[7][1] n836 destinationAddressbuffer[5][1]
+ n859 AOI22X1TS
XU1164 n619 n618 n617 n616 n615 NAND4XLTS
XU1165 n621 destinationAddressOut[1] FE_DBTN45_n672 n1925 n619 AOI22X1TS
XU1169 n642 destinationAddressIn_NORTH[2] n689 destinationAddressIn_EAST[2]
+ n643 AOI22X1TS
XU1174 n641 destinationAddressIn_SOUTH[2] n542 destinationAddressIn_WEST[2]
+ n610 AOI22X1TS
XU1178 n637 destinationAddressbuffer[2][2] n717 destinationAddressbuffer[0][2]
+ n691 AOI22X1TS
XU1181 n636 destinationAddressbuffer[6][2] n718 destinationAddressbuffer[4][2]
+ n692 AOI22X1TS
XU1184 n635 destinationAddressbuffer[3][2] n719 destinationAddressbuffer[1][2]
+ n693 AOI22X1TS
XU1186 n634 destinationAddressbuffer[7][2] n836 destinationAddressbuffer[5][2]
+ n859 AOI22X1TS
XU1187 n638 n637 n636 n635 n634 NAND4XLTS
XU1188 n640 destinationAddressOut[2] FE_DBTN45_n672 n1925 n638 AOI22X1TS
XU1191 n654 destinationAddressIn_NORTH[3] n689 destinationAddressIn_EAST[3]
+ n643 AOI22X1TS
XU1194 n653 destinationAddressIn_SOUTH[3] n542 destinationAddressIn_WEST[3]
+ n610 AOI22X1TS
XU1195 n648 destinationAddressbuffer[2][3] n717 destinationAddressbuffer[0][3]
+ n691 AOI22X1TS
XU1196 n647 destinationAddressbuffer[6][3] n718 destinationAddressbuffer[4][3]
+ n692 AOI22X1TS
XU1197 n646 destinationAddressbuffer[3][3] n719 destinationAddressbuffer[1][3]
+ n693 AOI22X1TS
XU1198 n645 destinationAddressbuffer[7][3] n836 destinationAddressbuffer[5][3]
+ n859 AOI22X1TS
XU1199 n649 n648 n647 n646 n645 NAND4XLTS
XU1200 n652 destinationAddressOut[3] FE_DBTN45_n672 n1925 n649 AOI22X1TS
XU1201 n665 destinationAddressIn_EAST[4] n643 destinationAddressIn_WEST[4] n610
+ AOI22X1TS
XU1202 n664 destinationAddressIn_NORTH[4] n689 destinationAddressIn_SOUTH[4]
+ n542 AOI22X1TS
XU1203 n766 n1926 INVX2TS
XU1205 n661 destinationAddressbuffer[2][4] n717 destinationAddressbuffer[0][4]
+ n691 AOI22X1TS
XU1206 n660 destinationAddressbuffer[6][4] n718 destinationAddressbuffer[4][4]
+ n692 AOI22X1TS
XU1207 n659 destinationAddressbuffer[3][4] n719 destinationAddressbuffer[1][4]
+ n693 AOI22X1TS
XU1209 n658 destinationAddressbuffer[7][4] n836 destinationAddressbuffer[5][4]
+ n859 AOI22X1TS
XU1210 n662 n661 n660 n659 n658 NAND4XLTS
XU1211 n663 destinationAddressOut[4] FE_DBTN45_n672 n766 n662 AOI22X1TS
XU1213 n687 destinationAddressIn_EAST[5] n643 destinationAddressIn_WEST[5] n610
+ AOI22X1TS
XU1215 n686 destinationAddressIn_NORTH[5] n689 destinationAddressIn_SOUTH[5]
+ n542 AOI22X1TS
XU1217 n683 destinationAddressbuffer[2][5] n717 destinationAddressbuffer[0][5]
+ n691 AOI22X1TS
XU1218 n682 destinationAddressbuffer[6][5] n718 destinationAddressbuffer[4][5]
+ n692 AOI22X1TS
XU1219 n681 destinationAddressbuffer[3][5] n719 destinationAddressbuffer[1][5]
+ n693 AOI22X1TS
XU1220 n680 destinationAddressbuffer[7][5] n836 destinationAddressbuffer[5][5]
+ n859 AOI22X1TS
XU1221 n684 n683 n682 n681 n680 NAND4XLTS
XU1222 n685 destinationAddressOut[5] FE_DBTN45_n672 n766 n684 AOI22X1TS
XU1224 n702 destinationAddressIn_EAST[6] n643 destinationAddressIn_WEST[6] n610
+ AOI22X1TS
XU1226 n701 destinationAddressIn_NORTH[6] n689 destinationAddressIn_SOUTH[6]
+ n542 AOI22X1TS
XU1229 n697 destinationAddressbuffer[2][6] n717 destinationAddressbuffer[0][6]
+ n691 AOI22X1TS
XU1232 n696 destinationAddressbuffer[6][6] n718 destinationAddressbuffer[4][6]
+ n692 AOI22X1TS
XU1235 n695 destinationAddressbuffer[3][6] n719 destinationAddressbuffer[1][6]
+ n693 AOI22X1TS
XU1238 n694 destinationAddressbuffer[7][6] n836 destinationAddressbuffer[5][6]
+ n859 AOI22X1TS
XU1239 n698 n697 n696 n695 n694 NAND4XLTS
XU1240 n700 destinationAddressOut[6] FE_DBTN45_n672 n766 n698 AOI22X1TS
XU1241 n713 destinationAddressIn_EAST[7] n643 destinationAddressIn_WEST[7] n610
+ AOI22X1TS
XU1242 n712 destinationAddressIn_NORTH[7] n689 destinationAddressIn_SOUTH[7]
+ n542 AOI22X1TS
XU1244 n709 destinationAddressbuffer[2][7] n717 destinationAddressbuffer[0][7]
+ n691 AOI22X1TS
XU1245 n708 destinationAddressbuffer[6][7] n718 destinationAddressbuffer[4][7]
+ n692 AOI22X1TS
XU1246 n707 destinationAddressbuffer[3][7] n719 destinationAddressbuffer[1][7]
+ n693 AOI22X1TS
XU1247 n706 destinationAddressbuffer[7][7] n836 destinationAddressbuffer[5][7]
+ n859 AOI22X1TS
XU1248 n710 n709 n708 n707 n706 NAND4XLTS
XU1249 n711 destinationAddressOut[7] FE_DBTN45_n672 n766 n710 AOI22X1TS
XU1250 n727 destinationAddressIn_EAST[8] n643 destinationAddressIn_WEST[8] n610
+ AOI22X1TS
XU1251 n726 destinationAddressIn_NORTH[8] n689 destinationAddressIn_SOUTH[8]
+ n542 AOI22X1TS
XU1253 n723 destinationAddressbuffer[2][8] n717 destinationAddressbuffer[0][8]
+ n691 AOI22X1TS
XU1255 n722 destinationAddressbuffer[6][8] n718 destinationAddressbuffer[4][8]
+ n692 AOI22X1TS
XU1257 n721 destinationAddressbuffer[3][8] n719 destinationAddressbuffer[1][8]
+ n693 AOI22X1TS
XU1258 n720 destinationAddressbuffer[7][8] n836 destinationAddressbuffer[5][8]
+ n859 AOI22X1TS
XU1259 n724 n723 n722 n721 n720 NAND4XLTS
XU1260 n725 destinationAddressOut[8] FE_DBTN45_n672 n766 n724 AOI22X1TS
XU1261 n745 destinationAddressIn_EAST[9] n643 destinationAddressIn_WEST[9] n610
+ AOI22X1TS
XU1262 n744 destinationAddressIn_NORTH[9] n689 destinationAddressIn_SOUTH[9]
+ n542 AOI22X1TS
XU1263 n740 destinationAddressbuffer[2][9] n717 destinationAddressbuffer[0][9]
+ n691 AOI22X1TS
XU1264 n739 destinationAddressbuffer[6][9] n718 destinationAddressbuffer[4][9]
+ n692 AOI22X1TS
XU1265 n738 destinationAddressbuffer[3][9] n719 destinationAddressbuffer[1][9]
+ n693 AOI22X1TS
XU1266 n737 destinationAddressbuffer[7][9] n836 destinationAddressbuffer[5][9]
+ n859 AOI22X1TS
XU1267 n741 n740 n739 n738 n737 NAND4XLTS
XU1268 n743 destinationAddressOut[9] FE_DBTN45_n672 n766 n741 AOI22X1TS
XU1270 n760 destinationAddressIn_EAST[10] n643 destinationAddressIn_WEST[10]
+ n610 AOI22X1TS
XU1272 n759 destinationAddressIn_NORTH[10] n689 destinationAddressIn_SOUTH[10]
+ n542 AOI22X1TS
XU1275 n755 destinationAddressbuffer[2][10] n717
+ destinationAddressbuffer[0][10] n691 AOI22X1TS
XU1278 n754 destinationAddressbuffer[6][10] n718
+ destinationAddressbuffer[4][10] n692 AOI22X1TS
XU1281 n753 destinationAddressbuffer[3][10] n719
+ destinationAddressbuffer[1][10] n693 AOI22X1TS
XU1283 n752 destinationAddressbuffer[7][10] n836
+ destinationAddressbuffer[5][10] n859 AOI22X1TS
XU1284 n756 n755 n754 n753 n752 NAND4XLTS
XU1285 n758 destinationAddressOut[10] FE_DBTN45_n672 n766 n756 AOI22X1TS
XU1286 n774 destinationAddressIn_EAST[11] n643 destinationAddressIn_WEST[11]
+ n610 AOI22X1TS
XU1287 n773 destinationAddressIn_NORTH[11] n689 destinationAddressIn_SOUTH[11]
+ n542 AOI22X1TS
XU1289 n770 destinationAddressbuffer[2][11] n717
+ destinationAddressbuffer[0][11] n691 AOI22X1TS
XU1290 n769 destinationAddressbuffer[6][11] n718
+ destinationAddressbuffer[4][11] n692 AOI22X1TS
XU1291 n768 destinationAddressbuffer[3][11] n719
+ destinationAddressbuffer[1][11] n693 AOI22X1TS
XU1292 n767 destinationAddressbuffer[7][11] n836
+ destinationAddressbuffer[5][11] n859 AOI22X1TS
XU1293 n771 n770 n769 n768 n767 NAND4XLTS
XU1294 n772 destinationAddressOut[11] FE_DBTN45_n672 n766 n771 AOI22X1TS
XU1298 n784 dataIn_NORTH[0] n689 dataIn_EAST[0] n643 AOI22X1TS
XU1301 n783 dataIn_SOUTH[0] n542 dataIn_WEST[0] n610 AOI22X1TS
XU1302 n779 dataoutbuffer[0][0] n691 dataoutbuffer[2][0] n717 AOI22X1TS
XU1303 n778 dataoutbuffer[4][0] n692 dataoutbuffer[6][0] n718 AOI22X1TS
XU1304 n777 dataoutbuffer[1][0] n693 dataoutbuffer[3][0] n719 AOI22X1TS
XU1305 n776 dataoutbuffer[5][0] n859 dataoutbuffer[7][0] n836 AOI22X1TS
XU1306 n780 n779 n778 n777 n776 NAND4XLTS
XU1307 n782 dataOut[0] FE_DBTN45_n672 n766 n780 AOI22X1TS
XU1310 n781 cacheDataOut[0] FE_DBTN41_n558 NAND2X1TS
XU1313 n804 dataIn_NORTH[1] n689 dataIn_EAST[1] n643 AOI22X1TS
XU1316 n803 dataIn_SOUTH[1] n542 dataIn_WEST[1] n610 AOI22X1TS
XU1317 n799 dataoutbuffer[0][1] n691 dataoutbuffer[2][1] n717 AOI22X1TS
XU1318 n798 dataoutbuffer[4][1] n692 dataoutbuffer[6][1] n718 AOI22X1TS
XU1319 n797 dataoutbuffer[1][1] n693 dataoutbuffer[3][1] n719 AOI22X1TS
XU1320 n796 dataoutbuffer[5][1] n859 dataoutbuffer[7][1] n836 AOI22X1TS
XU1321 n800 n799 n798 n797 n796 NAND4XLTS
XU1322 n802 dataOut[1] FE_DBTN45_n672 n766 n800 AOI22X1TS
XU1325 n801 cacheDataOut[1] FE_DBTN41_n558 NAND2X1TS
XU1329 n823 dataIn_NORTH[2] n689 dataIn_EAST[2] n643 AOI22X1TS
XU1333 n822 dataIn_SOUTH[2] n542 dataIn_WEST[2] n610 AOI22X1TS
XU1336 n817 dataoutbuffer[0][2] n691 dataoutbuffer[2][2] n717 AOI22X1TS
XU1339 n816 dataoutbuffer[4][2] n692 dataoutbuffer[6][2] n718 AOI22X1TS
XU1342 n815 dataoutbuffer[1][2] n693 dataoutbuffer[3][2] n719 AOI22X1TS
XU1343 n814 dataoutbuffer[5][2] n859 dataoutbuffer[7][2] n836 AOI22X1TS
XU1344 n818 n817 n816 n815 n814 NAND4XLTS
XU1345 n821 dataOut[2] FE_DBTN45_n672 n766 n818 AOI22X1TS
XU1347 n820 cacheDataOut[2] FE_DBTN41_n558 NAND2X1TS
XU1350 n835 dataIn_NORTH[3] n689 dataIn_EAST[3] n643 AOI22X1TS
XU1353 n834 dataIn_SOUTH[3] n542 dataIn_WEST[3] n610 AOI22X1TS
XU1354 n829 dataoutbuffer[0][3] n691 dataoutbuffer[2][3] n717 AOI22X1TS
XU1355 n828 dataoutbuffer[4][3] n692 dataoutbuffer[6][3] n718 AOI22X1TS
XU1356 n827 dataoutbuffer[1][3] n693 dataoutbuffer[3][3] n719 AOI22X1TS
XU1357 n826 dataoutbuffer[5][3] n859 dataoutbuffer[7][3] n836 AOI22X1TS
XU1358 n830 n829 n828 n827 n826 NAND4XLTS
XU1359 n833 dataOut[3] FE_DBTN45_n672 n1925 n830 AOI22X1TS
XU1361 n832 cacheDataOut[3] FE_DBTN41_n558 NAND2X1TS
XU1364 n847 dataIn_NORTH[4] n689 dataIn_EAST[4] n643 AOI22X1TS
XU1367 n846 dataIn_SOUTH[4] n542 dataIn_WEST[4] n610 AOI22X1TS
XU1368 n840 dataoutbuffer[0][4] n691 dataoutbuffer[2][4] n717 AOI22X1TS
XU1369 n839 dataoutbuffer[4][4] n692 dataoutbuffer[6][4] n718 AOI22X1TS
XU1370 n838 dataoutbuffer[1][4] n693 dataoutbuffer[3][4] n719 AOI22X1TS
XU1371 n837 dataoutbuffer[5][4] n859 dataoutbuffer[7][4] n836 AOI22X1TS
XU1372 n841 n840 n839 n838 n837 NAND4XLTS
XU1373 n845 dataOut[4] FE_DBTN45_n672 n1925 n841 AOI22X1TS
XU1375 n844 cacheDataOut[4] FE_DBTN41_n558 NAND2X1TS
XU1378 n871 dataIn_NORTH[5] n689 dataIn_EAST[5] n643 AOI22X1TS
XU1381 n870 dataIn_SOUTH[5] n542 dataIn_WEST[5] n610 AOI22X1TS
XU1382 n863 dataoutbuffer[0][5] n691 dataoutbuffer[2][5] n717 AOI22X1TS
XU1383 n862 dataoutbuffer[4][5] n692 dataoutbuffer[6][5] n718 AOI22X1TS
XU1384 n861 dataoutbuffer[1][5] n693 dataoutbuffer[3][5] n719 AOI22X1TS
XU1385 n860 dataoutbuffer[5][5] n859 dataoutbuffer[7][5] n836 AOI22X1TS
XU1386 n864 n863 n862 n861 n860 NAND4XLTS
XU1387 n869 dataOut[5] FE_DBTN45_n672 n766 n864 AOI22X1TS
XU1389 n868 cacheDataOut[5] FE_DBTN41_n558 NAND2X1TS
XU1392 n877 readRequesterAddress[0] n34 FE_DBTN69_n1527
+ requesterAddressbuffer[7][0] AOI22X1TS
XU1396 n876 FE_DBTN68_n55 requesterAddressIn_WEST[0] n32
+ requesterAddressIn_EAST[0] AOI22X1TS
XU1401 n875 n51 requesterAddressIn_SOUTH[0] FE_DBTN70_n59
+ requesterAddressIn_NORTH[0] AOI22X1TS
XU1403 n880 n34 readRequesterAddress[1] FE_DBTN69_n1527
+ requesterAddressbuffer[7][1] AOI22X1TS
XU1406 n879 FE_DBTN68_n55 requesterAddressIn_WEST[1] n32
+ requesterAddressIn_EAST[1] AOI22X1TS
XU1409 n878 n51 requesterAddressIn_SOUTH[1] FE_DBTN70_n59
+ requesterAddressIn_NORTH[1] AOI22X1TS
XU1411 n884 n34 readRequesterAddress[2] FE_DBTN69_n1527
+ requesterAddressbuffer[7][2] AOI22X1TS
XU1413 n883 FE_DBTN68_n55 requesterAddressIn_WEST[2] n32
+ requesterAddressIn_EAST[2] AOI22X1TS
XU1416 n882 n51 requesterAddressIn_SOUTH[2] FE_DBTN70_n59
+ requesterAddressIn_NORTH[2] AOI22X1TS
XU1418 n889 n34 readRequesterAddress[3] FE_DBTN69_n1527
+ requesterAddressbuffer[7][3] AOI22X1TS
XU1420 n888 FE_DBTN68_n55 requesterAddressIn_WEST[3] n32
+ requesterAddressIn_EAST[3] AOI22X1TS
XU1423 n887 n51 requesterAddressIn_SOUTH[3] FE_DBTN70_n59
+ requesterAddressIn_NORTH[3] AOI22X1TS
XU1426 n892 readRequesterAddress[0] n86 FE_DBTN66_n1475
+ requesterAddressbuffer[6][0] AOI22X1TS
XU1428 n891 requesterAddressIn_WEST[0] FE_DBTN65_n106
+ requesterAddressIn_EAST[0] n84 AOI22X1TS
XU1429 n890 requesterAddressIn_SOUTH[0] n92 requesterAddressIn_NORTH[0]
+ FE_DBTN77_n5 AOI22X1TS
XU1431 n897 readRequesterAddress[1] n86 FE_DBTN66_n1475
+ requesterAddressbuffer[6][1] AOI22X1TS
XU1433 n896 requesterAddressIn_WEST[1] FE_DBTN65_n106
+ requesterAddressIn_EAST[1] n84 AOI22X1TS
XU1435 n895 requesterAddressIn_SOUTH[1] n92 requesterAddressIn_NORTH[1]
+ FE_DBTN77_n5 AOI22X1TS
XU1439 n900 readRequesterAddress[2] n86 FE_DBTN66_n1475
+ requesterAddressbuffer[6][2] AOI22X1TS
XU1440 n899 requesterAddressIn_WEST[2] FE_DBTN65_n106
+ requesterAddressIn_EAST[2] n84 AOI22X1TS
XU1441 n898 requesterAddressIn_SOUTH[2] n92 requesterAddressIn_NORTH[2]
+ FE_DBTN77_n5 AOI22X1TS
XU1443 n906 readRequesterAddress[3] n86 FE_DBTN66_n1475
+ requesterAddressbuffer[6][3] AOI22X1TS
XU1445 n905 requesterAddressIn_WEST[3] FE_DBTN65_n106
+ requesterAddressIn_EAST[3] n84 AOI22X1TS
XU1447 n904 requesterAddressIn_SOUTH[3] n92 requesterAddressIn_NORTH[3]
+ FE_DBTN77_n5 AOI22X1TS
XU1449 n910 readRequesterAddress[0] n222 FE_DBTN57_n1438
+ requesterAddressbuffer[5][0] AOI22X1TS
XU1451 n909 requesterAddressIn_WEST[0] FE_DBTN59_n239
+ requesterAddressIn_EAST[0] n221 AOI22X1TS
XU1453 n908 requesterAddressIn_SOUTH[0] FE_DBTN58_n245
+ requesterAddressIn_NORTH[0] FE_DBTN81_n1 AOI22X1TS
XU1454 n914 readRequesterAddress[1] n222 FE_DBTN57_n1438
+ requesterAddressbuffer[5][1] AOI22X1TS
XU1456 n913 requesterAddressIn_WEST[1] FE_DBTN59_n239
+ requesterAddressIn_EAST[1] n221 AOI22X1TS
XU1457 n912 requesterAddressIn_SOUTH[1] FE_DBTN58_n245
+ requesterAddressIn_NORTH[1] FE_DBTN81_n1 AOI22X1TS
XU1460 n917 readRequesterAddress[2] n222 FE_DBTN57_n1438
+ requesterAddressbuffer[5][2] AOI22X1TS
XU1461 n916 requesterAddressIn_WEST[2] FE_DBTN59_n239
+ requesterAddressIn_EAST[2] n221 AOI22X1TS
XU1462 n915 requesterAddressIn_SOUTH[2] FE_DBTN58_n245
+ requesterAddressIn_NORTH[2] FE_DBTN81_n1 AOI22X1TS
XU1463 n922 readRequesterAddress[3] n222 FE_DBTN57_n1438
+ requesterAddressbuffer[5][3] AOI22X1TS
XU1465 n921 requesterAddressIn_WEST[3] FE_DBTN59_n239
+ requesterAddressIn_EAST[3] n221 AOI22X1TS
XU1466 n920 requesterAddressIn_SOUTH[3] FE_DBTN58_n245
+ requesterAddressIn_NORTH[3] FE_DBTN81_n1 AOI22X1TS
XU1468 n929 readRequesterAddress[0] n274 FE_DBTN54_n1406
+ requesterAddressbuffer[4][0] AOI22X1TS
XU1470 n928 requesterAddressIn_WEST[0] FE_DBTN55_n289
+ requesterAddressIn_EAST[0] n272 AOI22X1TS
XU1471 n927 requesterAddressIn_SOUTH[0] FE_DBTN80_n2
+ requesterAddressIn_NORTH[0] FE_DBTN75_n7 AOI22X1TS
XU1473 n935 readRequesterAddress[1] n274 FE_DBTN54_n1406
+ requesterAddressbuffer[4][1] AOI22X1TS
XU1475 n934 requesterAddressIn_WEST[1] FE_DBTN55_n289
+ requesterAddressIn_EAST[1] n272 AOI22X1TS
XU1476 n933 requesterAddressIn_SOUTH[1] FE_DBTN80_n2
+ requesterAddressIn_NORTH[1] FE_DBTN75_n7 AOI22X1TS
XU1480 n940 readRequesterAddress[2] n274 FE_DBTN54_n1406
+ requesterAddressbuffer[4][2] AOI22X1TS
XU1481 n939 requesterAddressIn_WEST[2] FE_DBTN55_n289
+ requesterAddressIn_EAST[2] n272 AOI22X1TS
XU1482 n938 requesterAddressIn_SOUTH[2] FE_DBTN80_n2
+ requesterAddressIn_NORTH[2] FE_DBTN75_n7 AOI22X1TS
XU1485 n947 readRequesterAddress[3] n274 FE_DBTN54_n1406
+ requesterAddressbuffer[4][3] AOI22X1TS
XU1487 n946 requesterAddressIn_WEST[3] FE_DBTN55_n289
+ requesterAddressIn_EAST[3] n272 AOI22X1TS
XU1488 n945 requesterAddressIn_SOUTH[3] FE_DBTN80_n2
+ requesterAddressIn_NORTH[3] FE_DBTN75_n7 AOI22X1TS
XU1491 n953 readRequesterAddress[0] n134 FE_DBTN63_n1377
+ requesterAddressbuffer[3][0] AOI22X1TS
XU1492 n952 requesterAddressIn_WEST[0] FE_DBTN76_n6 requesterAddressIn_EAST[0]
+ n141 AOI22X1TS
XU1494 n951 requesterAddressIn_SOUTH[0] n132 requesterAddressIn_NORTH[0]
+ FE_DBTN62_n163 AOI22X1TS
XU1496 n962 readRequesterAddress[1] n134 FE_DBTN63_n1377
+ requesterAddressbuffer[3][1] AOI22X1TS
XU1498 n961 requesterAddressIn_WEST[1] FE_DBTN76_n6 requesterAddressIn_EAST[1]
+ n141 AOI22X1TS
XU1500 n960 requesterAddressIn_SOUTH[1] n132 requesterAddressIn_NORTH[1]
+ FE_DBTN62_n163 AOI22X1TS
XU1504 n970 readRequesterAddress[2] n134 FE_DBTN63_n1377
+ requesterAddressbuffer[3][2] AOI22X1TS
XU1505 n969 requesterAddressIn_WEST[2] FE_DBTN76_n6 requesterAddressIn_EAST[2]
+ n141 AOI22X1TS
XU1506 n968 requesterAddressIn_SOUTH[2] n132 requesterAddressIn_NORTH[2]
+ FE_DBTN62_n163 AOI22X1TS
XU1508 n977 readRequesterAddress[3] n134 FE_DBTN63_n1377
+ requesterAddressbuffer[3][3] AOI22X1TS
XU1509 n976 requesterAddressIn_WEST[3] FE_DBTN76_n6 requesterAddressIn_EAST[3]
+ n141 AOI22X1TS
XU1510 n975 requesterAddressIn_SOUTH[3] n132 requesterAddressIn_NORTH[3]
+ FE_DBTN62_n163 AOI22X1TS
XU1512 n980 readRequesterAddress[0] FE_DBTN72_n11 FE_DBTN60_n1343
+ requesterAddressbuffer[2][0] AOI22X1TS
XU1514 n979 requesterAddressIn_WEST[0] FE_DBTN61_n197
+ requesterAddressIn_EAST[0] n180 AOI22X1TS
XU1515 n978 requesterAddressIn_SOUTH[0] n186 requesterAddressIn_NORTH[0] n199
+ AOI22X1TS
XU1516 n984 readRequesterAddress[1] FE_DBTN72_n11 FE_DBTN60_n1343
+ requesterAddressbuffer[2][1] AOI22X1TS
XU1518 n983 requesterAddressIn_WEST[1] FE_DBTN61_n197
+ requesterAddressIn_EAST[1] n180 AOI22X1TS
XU1520 n982 requesterAddressIn_SOUTH[1] n186 requesterAddressIn_NORTH[1] n199
+ AOI22X1TS
XU1523 n988 readRequesterAddress[2] FE_DBTN72_n11 FE_DBTN60_n1343
+ requesterAddressbuffer[2][2] AOI22X1TS
XU1524 n987 requesterAddressIn_WEST[2] FE_DBTN61_n197
+ requesterAddressIn_EAST[2] n180 AOI22X1TS
XU1525 n986 requesterAddressIn_SOUTH[2] n186 requesterAddressIn_NORTH[2] n199
+ AOI22X1TS
XU1527 n994 readRequesterAddress[3] FE_DBTN72_n11 FE_DBTN60_n1343
+ requesterAddressbuffer[2][3] AOI22X1TS
XU1529 n993 requesterAddressIn_WEST[3] FE_DBTN61_n197
+ requesterAddressIn_EAST[3] n180 AOI22X1TS
XU1531 n992 requesterAddressIn_SOUTH[3] n186 requesterAddressIn_NORTH[3] n199
+ AOI22X1TS
XU1533 n1001 readRequesterAddress[0] n315 FE_DBTN52_n354
+ requesterAddressbuffer[1][0] AOI22X1TS
XU1535 n1000 requesterAddressIn_WEST[0] FE_DBTN53_n341
+ requesterAddressIn_EAST[0] n313 AOI22X1TS
XU1536 n999 requesterAddressIn_SOUTH[0] n322 requesterAddressIn_NORTH[0]
+ FE_DBTN78_n4 AOI22X1TS
XU1537 n1009 readRequesterAddress[1] n315 FE_DBTN52_n354
+ requesterAddressbuffer[1][1] AOI22X1TS
XU1539 n1008 requesterAddressIn_WEST[1] FE_DBTN53_n341
+ requesterAddressIn_EAST[1] n313 AOI22X1TS
XU1541 n1007 requesterAddressIn_SOUTH[1] n322 requesterAddressIn_NORTH[1]
+ FE_DBTN78_n4 AOI22X1TS
XU1544 n1016 readRequesterAddress[2] n315 FE_DBTN52_n354
+ requesterAddressbuffer[1][2] AOI22X1TS
XU1545 n1015 requesterAddressIn_WEST[2] FE_DBTN53_n341
+ requesterAddressIn_EAST[2] n313 AOI22X1TS
XU1546 n1014 requesterAddressIn_SOUTH[2] n322 requesterAddressIn_NORTH[2]
+ FE_DBTN78_n4 AOI22X1TS
XU1548 n1025 readRequesterAddress[3] n315 FE_DBTN52_n354
+ requesterAddressbuffer[1][3] AOI22X1TS
XU1550 n1024 requesterAddressIn_WEST[3] FE_DBTN53_n341
+ requesterAddressIn_EAST[3] n313 AOI22X1TS
XU1552 n1023 requesterAddressIn_SOUTH[3] n322 requesterAddressIn_NORTH[3]
+ FE_DBTN78_n4 AOI22X1TS
XU1554 n1032 readRequesterAddress[0] FE_DBTN71_n12 FE_DBTN49_n422
+ requesterAddressbuffer[0][0] AOI22X1TS
XU1556 n1031 requesterAddressIn_WEST[0] FE_DBTN48_n416
+ requesterAddressIn_EAST[0] n390 AOI22X1TS
XU1559 n1030 requesterAddressIn_SOUTH[0] FE_DBTN79_n3
+ requesterAddressIn_NORTH[0] FE_DBTN74_n8 AOI22X1TS
XU1560 n1038 readRequesterAddress[1] FE_DBTN71_n12 FE_DBTN49_n422
+ requesterAddressbuffer[0][1] AOI22X1TS
XU1562 n1037 requesterAddressIn_WEST[1] FE_DBTN48_n416
+ requesterAddressIn_EAST[1] n390 AOI22X1TS
XU1563 n1036 requesterAddressIn_SOUTH[1] FE_DBTN79_n3
+ requesterAddressIn_NORTH[1] FE_DBTN74_n8 AOI22X1TS
XU1566 n1043 readRequesterAddress[2] FE_DBTN71_n12 FE_DBTN49_n422
+ requesterAddressbuffer[0][2] AOI22X1TS
XU1567 n1042 requesterAddressIn_WEST[2] FE_DBTN48_n416
+ requesterAddressIn_EAST[2] n390 AOI22X1TS
XU1568 n1041 requesterAddressIn_SOUTH[2] FE_DBTN79_n3
+ requesterAddressIn_NORTH[2] FE_DBTN74_n8 AOI22X1TS
XU1570 n1050 readRequesterAddress[3] FE_DBTN71_n12 FE_DBTN49_n422
+ requesterAddressbuffer[0][3] AOI22X1TS
XU1572 n1049 requesterAddressIn_WEST[3] FE_DBTN48_n416
+ requesterAddressIn_EAST[3] n390 AOI22X1TS
XU1573 n1048 requesterAddressIn_SOUTH[3] FE_DBTN79_n3
+ requesterAddressIn_NORTH[3] FE_DBTN74_n8 AOI22X1TS
XU1575 n1054 FE_DBTN71_n12 cacheDataOut[0] FE_DBTN49_n422 dataoutbuffer[0][0]
+ AOI22X1TS
XU1576 n1053 FE_DBTN48_n416 dataIn_WEST[0] n390 dataIn_EAST[0] AOI22X1TS
XU1578 n1052 FE_DBTN79_n3 dataIn_SOUTH[0] FE_DBTN74_n8 dataIn_NORTH[0]
+ AOI22X1TS
XU1580 n1059 FE_DBTN71_n12 cacheDataOut[1] FE_DBTN49_n422 dataoutbuffer[0][1]
+ AOI22X1TS
XU1581 n1058 FE_DBTN48_n416 dataIn_WEST[1] n390 dataIn_EAST[1] AOI22X1TS
XU1583 n1057 FE_DBTN79_n3 dataIn_SOUTH[1] FE_DBTN74_n8 dataIn_NORTH[1]
+ AOI22X1TS
XU1587 n1065 FE_DBTN71_n12 cacheDataOut[2] FE_DBTN49_n422 dataoutbuffer[0][2]
+ AOI22X1TS
XU1588 n1064 FE_DBTN48_n416 dataIn_WEST[2] n390 dataIn_EAST[2] AOI22X1TS
XU1590 n1063 FE_DBTN79_n3 dataIn_SOUTH[2] FE_DBTN74_n8 dataIn_NORTH[2]
+ AOI22X1TS
XU1592 n1068 FE_DBTN71_n12 cacheDataOut[3] FE_DBTN49_n422 dataoutbuffer[0][3]
+ AOI22X1TS
XU1593 n1067 FE_DBTN48_n416 dataIn_WEST[3] n390 dataIn_EAST[3] AOI22X1TS
XU1595 n1066 FE_DBTN79_n3 dataIn_SOUTH[3] FE_DBTN74_n8 dataIn_NORTH[3]
+ AOI22X1TS
XU1597 n1072 FE_DBTN71_n12 cacheDataOut[4] FE_DBTN49_n422 dataoutbuffer[0][4]
+ AOI22X1TS
XU1598 n1071 FE_DBTN48_n416 dataIn_WEST[4] n390 dataIn_EAST[4] AOI22X1TS
XU1600 n1070 FE_DBTN79_n3 dataIn_SOUTH[4] FE_DBTN74_n8 dataIn_NORTH[4]
+ AOI22X1TS
XU1602 n1076 FE_DBTN71_n12 cacheDataOut[5] FE_DBTN49_n422 dataoutbuffer[0][5]
+ AOI22X1TS
XU1603 n1075 FE_DBTN48_n416 dataIn_WEST[5] n390 dataIn_EAST[5] AOI22X1TS
XU1605 n1074 FE_DBTN79_n3 dataIn_SOUTH[5] FE_DBTN74_n8 dataIn_NORTH[5]
+ AOI22X1TS
XU1607 n1080 n315 cacheDataOut[0] FE_DBTN52_n354 dataoutbuffer[1][0] AOI22X1TS
XU1608 n1079 FE_DBTN53_n341 dataIn_WEST[0] n313 dataIn_EAST[0] AOI22X1TS
XU1612 n1078 FE_DBTN78_n4 dataIn_NORTH[0] n322 dataIn_SOUTH[0] AOI22X1TS
XU1614 n1085 n315 cacheDataOut[1] FE_DBTN52_n354 dataoutbuffer[1][1] AOI22X1TS
XU1615 n1084 FE_DBTN53_n341 dataIn_WEST[1] n313 dataIn_EAST[1] AOI22X1TS
XU1619 n1083 FE_DBTN78_n4 dataIn_NORTH[1] n322 dataIn_SOUTH[1] AOI22X1TS
XU1622 n1094 n315 cacheDataOut[2] FE_DBTN52_n354 dataoutbuffer[1][2] AOI22X1TS
XU1623 n1093 FE_DBTN53_n341 dataIn_WEST[2] n313 dataIn_EAST[2] AOI22X1TS
XU1627 n1092 FE_DBTN78_n4 dataIn_NORTH[2] n322 dataIn_SOUTH[2] AOI22X1TS
XU1629 n1098 n315 cacheDataOut[3] FE_DBTN52_n354 dataoutbuffer[1][3] AOI22X1TS
XU1630 n1097 FE_DBTN53_n341 dataIn_WEST[3] n313 dataIn_EAST[3] AOI22X1TS
XU1634 n1096 FE_DBTN78_n4 dataIn_NORTH[3] n322 dataIn_SOUTH[3] AOI22X1TS
XU1636 n1102 n315 cacheDataOut[4] FE_DBTN52_n354 dataoutbuffer[1][4] AOI22X1TS
XU1637 n1101 FE_DBTN53_n341 dataIn_WEST[4] n313 dataIn_EAST[4] AOI22X1TS
XU1641 n1100 FE_DBTN78_n4 dataIn_NORTH[4] n322 dataIn_SOUTH[4] AOI22X1TS
XU1643 n1108 n315 cacheDataOut[5] FE_DBTN52_n354 dataoutbuffer[1][5] AOI22X1TS
XU1644 n1107 FE_DBTN53_n341 dataIn_WEST[5] n313 dataIn_EAST[5] AOI22X1TS
XU1648 n1106 FE_DBTN78_n4 dataIn_NORTH[5] n322 dataIn_SOUTH[5] AOI22X1TS
XU1649 n1112 FE_DBTN72_n11 cacheDataOut[0] FE_DBTN60_n1343 dataoutbuffer[2][0]
+ AOI22X1TS
XU1650 n1111 FE_DBTN61_n197 dataIn_WEST[0] n180 dataIn_EAST[0] AOI22X1TS
XU1651 n1110 n199 dataIn_NORTH[0] n186 dataIn_SOUTH[0] AOI22X1TS
XU1652 n1342 FE_DBTN72_n11 cacheDataOut[1] FE_DBTN60_n1343 dataoutbuffer[2][1]
+ AOI22X1TS
XU1653 n1341 FE_DBTN61_n197 dataIn_WEST[1] n180 dataIn_EAST[1] AOI22X1TS
XU1655 n1340 n199 dataIn_NORTH[1] n186 dataIn_SOUTH[1] AOI22X1TS
XU1658 n1351 FE_DBTN72_n11 cacheDataOut[2] FE_DBTN60_n1343 dataoutbuffer[2][2]
+ AOI22X1TS
XU1659 n1350 FE_DBTN61_n197 dataIn_WEST[2] n180 dataIn_EAST[2] AOI22X1TS
XU1660 n1349 n199 dataIn_NORTH[2] n186 dataIn_SOUTH[2] AOI22X1TS
XU1661 n1355 FE_DBTN72_n11 cacheDataOut[3] FE_DBTN60_n1343 dataoutbuffer[2][3]
+ AOI22X1TS
XU1662 n1354 FE_DBTN61_n197 dataIn_WEST[3] n180 dataIn_EAST[3] AOI22X1TS
XU1663 n1353 n199 dataIn_NORTH[3] n186 dataIn_SOUTH[3] AOI22X1TS
XU1664 n1359 FE_DBTN72_n11 cacheDataOut[4] FE_DBTN60_n1343 dataoutbuffer[2][4]
+ AOI22X1TS
XU1665 n1358 FE_DBTN61_n197 dataIn_WEST[4] n180 dataIn_EAST[4] AOI22X1TS
XU1666 n1357 n199 dataIn_NORTH[4] n186 dataIn_SOUTH[4] AOI22X1TS
XU1667 n1365 FE_DBTN72_n11 cacheDataOut[5] FE_DBTN60_n1343 dataoutbuffer[2][5]
+ AOI22X1TS
XU1668 n1364 FE_DBTN61_n197 dataIn_WEST[5] n180 dataIn_EAST[5] AOI22X1TS
XU1669 n1363 n199 dataIn_NORTH[5] n186 dataIn_SOUTH[5] AOI22X1TS
XU1670 n1369 n134 cacheDataOut[0] FE_DBTN63_n1377 dataoutbuffer[3][0] AOI22X1TS
XU1671 n1368 FE_DBTN76_n6 dataIn_WEST[0] n141 dataIn_EAST[0] AOI22X1TS
XU1672 n1367 FE_DBTN62_n163 dataIn_NORTH[0] n132 dataIn_SOUTH[0] AOI22X1TS
XU1673 n1375 n134 cacheDataOut[1] FE_DBTN63_n1377 dataoutbuffer[3][1] AOI22X1TS
XU1674 n1374 FE_DBTN76_n6 dataIn_WEST[1] n141 dataIn_EAST[1] AOI22X1TS
XU1676 n1373 FE_DBTN62_n163 dataIn_NORTH[1] n132 dataIn_SOUTH[1] AOI22X1TS
XU1679 n1380 n134 cacheDataOut[2] FE_DBTN63_n1377 dataoutbuffer[3][2] AOI22X1TS
XU1680 n1379 FE_DBTN76_n6 dataIn_WEST[2] n141 dataIn_EAST[2] AOI22X1TS
XU1681 n1378 FE_DBTN62_n163 dataIn_NORTH[2] n132 dataIn_SOUTH[2] AOI22X1TS
XU1682 n1383 n134 cacheDataOut[3] FE_DBTN63_n1377 dataoutbuffer[3][3] AOI22X1TS
XU1683 n1382 FE_DBTN76_n6 dataIn_WEST[3] n141 dataIn_EAST[3] AOI22X1TS
XU1684 n1381 FE_DBTN62_n163 dataIn_NORTH[3] n132 dataIn_SOUTH[3] AOI22X1TS
XU1685 n1389 n134 cacheDataOut[4] FE_DBTN63_n1377 dataoutbuffer[3][4] AOI22X1TS
XU1686 n1388 FE_DBTN76_n6 dataIn_WEST[4] n141 dataIn_EAST[4] AOI22X1TS
XU1687 n1387 FE_DBTN62_n163 dataIn_NORTH[4] n132 dataIn_SOUTH[4] AOI22X1TS
XU1688 n1394 n134 cacheDataOut[5] FE_DBTN63_n1377 dataoutbuffer[3][5] AOI22X1TS
XU1689 n1393 FE_DBTN76_n6 dataIn_WEST[5] n141 dataIn_EAST[5] AOI22X1TS
XU1690 n1392 FE_DBTN62_n163 dataIn_NORTH[5] n132 dataIn_SOUTH[5] AOI22X1TS
XU1691 n1399 n274 cacheDataOut[0] FE_DBTN54_n1406 dataoutbuffer[4][0] AOI22X1TS
XU1692 n1398 FE_DBTN55_n289 dataIn_WEST[0] n272 dataIn_EAST[0] AOI22X1TS
XU1693 n1397 FE_DBTN80_n2 dataIn_SOUTH[0] FE_DBTN75_n7 dataIn_NORTH[0]
+ AOI22X1TS
XU1694 n1404 n274 cacheDataOut[1] FE_DBTN54_n1406 dataoutbuffer[4][1] AOI22X1TS
XU1695 n1403 FE_DBTN55_n289 dataIn_WEST[1] n272 dataIn_EAST[1] AOI22X1TS
XU1696 n1402 FE_DBTN80_n2 dataIn_SOUTH[1] FE_DBTN75_n7 dataIn_NORTH[1]
+ AOI22X1TS
XU1698 n1413 n274 cacheDataOut[2] FE_DBTN54_n1406 dataoutbuffer[4][2] AOI22X1TS
XU1699 n1412 FE_DBTN55_n289 dataIn_WEST[2] n272 dataIn_EAST[2] AOI22X1TS
XU1700 n1411 FE_DBTN80_n2 dataIn_SOUTH[2] FE_DBTN75_n7 dataIn_NORTH[2]
+ AOI22X1TS
XU1701 n1417 n274 cacheDataOut[3] FE_DBTN54_n1406 dataoutbuffer[4][3] AOI22X1TS
XU1702 n1416 FE_DBTN55_n289 dataIn_WEST[3] n272 dataIn_EAST[3] AOI22X1TS
XU1703 n1415 FE_DBTN80_n2 dataIn_SOUTH[3] FE_DBTN75_n7 dataIn_NORTH[3]
+ AOI22X1TS
XU1704 n1421 n274 cacheDataOut[4] FE_DBTN54_n1406 dataoutbuffer[4][4] AOI22X1TS
XU1705 n1420 FE_DBTN55_n289 dataIn_WEST[4] n272 dataIn_EAST[4] AOI22X1TS
XU1706 n1419 FE_DBTN80_n2 dataIn_SOUTH[4] FE_DBTN75_n7 dataIn_NORTH[4]
+ AOI22X1TS
XU1707 n1427 n274 cacheDataOut[5] FE_DBTN54_n1406 dataoutbuffer[4][5] AOI22X1TS
XU1708 n1426 FE_DBTN55_n289 dataIn_WEST[5] n272 dataIn_EAST[5] AOI22X1TS
XU1709 n1425 FE_DBTN80_n2 dataIn_SOUTH[5] FE_DBTN75_n7 dataIn_NORTH[5]
+ AOI22X1TS
XU1710 n1432 n222 cacheDataOut[0] FE_DBTN57_n1438 dataoutbuffer[5][0] AOI22X1TS
XU1711 n1431 FE_DBTN59_n239 dataIn_WEST[0] n221 dataIn_EAST[0] AOI22X1TS
XU1712 n1430 FE_DBTN81_n1 dataIn_NORTH[0] FE_DBTN58_n245 dataIn_SOUTH[0]
+ AOI22X1TS
XU1713 n1436 n222 cacheDataOut[1] FE_DBTN57_n1438 dataoutbuffer[5][1] AOI22X1TS
XU1714 n1435 FE_DBTN59_n239 dataIn_WEST[1] n221 dataIn_EAST[1] AOI22X1TS
XU1715 n1434 FE_DBTN81_n1 dataIn_NORTH[1] FE_DBTN58_n245 dataIn_SOUTH[1]
+ AOI22X1TS
XU1718 n1443 n222 cacheDataOut[2] FE_DBTN57_n1438 dataoutbuffer[5][2] AOI22X1TS
XU1719 n1442 FE_DBTN59_n239 dataIn_WEST[2] n221 dataIn_EAST[2] AOI22X1TS
XU1720 n1441 FE_DBTN81_n1 dataIn_NORTH[2] FE_DBTN58_n245 dataIn_SOUTH[2]
+ AOI22X1TS
XU1721 n1449 n222 cacheDataOut[3] FE_DBTN57_n1438 dataoutbuffer[5][3] AOI22X1TS
XU1722 n1448 FE_DBTN59_n239 dataIn_WEST[3] n221 dataIn_EAST[3] AOI22X1TS
XU1723 n1447 FE_DBTN81_n1 dataIn_NORTH[3] FE_DBTN58_n245 dataIn_SOUTH[3]
+ AOI22X1TS
XU1724 n1453 n222 cacheDataOut[4] FE_DBTN57_n1438 dataoutbuffer[5][4] AOI22X1TS
XU1725 n1452 FE_DBTN59_n239 dataIn_WEST[4] n221 dataIn_EAST[4] AOI22X1TS
XU1727 n1451 FE_DBTN81_n1 dataIn_NORTH[4] FE_DBTN58_n245 dataIn_SOUTH[4]
+ AOI22X1TS
XU1728 n1457 n222 cacheDataOut[5] FE_DBTN57_n1438 dataoutbuffer[5][5] AOI22X1TS
XU1729 n1456 FE_DBTN59_n239 dataIn_WEST[5] n221 dataIn_EAST[5] AOI22X1TS
XU1730 n1455 FE_DBTN81_n1 dataIn_NORTH[5] FE_DBTN58_n245 dataIn_SOUTH[5]
+ AOI22X1TS
XU1731 n1465 n86 cacheDataOut[0] FE_DBTN66_n1475 dataoutbuffer[6][0] AOI22X1TS
XU1732 n1464 FE_DBTN65_n106 dataIn_WEST[0] n84 dataIn_EAST[0] AOI22X1TS
XU1733 n1463 FE_DBTN77_n5 dataIn_NORTH[0] n92 dataIn_SOUTH[0] AOI22X1TS
XU1734 n1473 n86 cacheDataOut[1] FE_DBTN66_n1475 dataoutbuffer[6][1] AOI22X1TS
XU1735 n1472 FE_DBTN65_n106 dataIn_WEST[1] n84 dataIn_EAST[1] AOI22X1TS
XU1736 n1471 FE_DBTN77_n5 dataIn_NORTH[1] n92 dataIn_SOUTH[1] AOI22X1TS
XU1739 n1485 n86 cacheDataOut[2] FE_DBTN66_n1475 dataoutbuffer[6][2] AOI22X1TS
XU1740 n1484 FE_DBTN65_n106 dataIn_WEST[2] n84 dataIn_EAST[2] AOI22X1TS
XU1741 n1483 FE_DBTN77_n5 dataIn_NORTH[2] n92 dataIn_SOUTH[2] AOI22X1TS
XU1742 n1493 n86 cacheDataOut[3] FE_DBTN66_n1475 dataoutbuffer[6][3] AOI22X1TS
XU1743 n1492 FE_DBTN65_n106 dataIn_WEST[3] n84 dataIn_EAST[3] AOI22X1TS
XU1744 n1491 FE_DBTN77_n5 dataIn_NORTH[3] n92 dataIn_SOUTH[3] AOI22X1TS
XU1745 n1500 n86 cacheDataOut[4] FE_DBTN66_n1475 dataoutbuffer[6][4] AOI22X1TS
XU1746 n1499 FE_DBTN65_n106 dataIn_WEST[4] n84 dataIn_EAST[4] AOI22X1TS
XU1747 n1498 FE_DBTN77_n5 dataIn_NORTH[4] n92 dataIn_SOUTH[4] AOI22X1TS
XU1748 n1509 n86 cacheDataOut[5] FE_DBTN66_n1475 dataoutbuffer[6][5] AOI22X1TS
XU1749 n1508 FE_DBTN65_n106 dataIn_WEST[5] n84 dataIn_EAST[5] AOI22X1TS
XU1750 n1507 FE_DBTN77_n5 dataIn_NORTH[5] n92 dataIn_SOUTH[5] AOI22X1TS
XU1751 n1518 n34 cacheDataOut[0] FE_DBTN69_n1527 dataoutbuffer[7][0] AOI22X1TS
XU1752 n1517 FE_DBTN68_n55 dataIn_WEST[0] n32 dataIn_EAST[0] AOI22X1TS
XU1753 n1516 n51 dataIn_SOUTH[0] FE_DBTN70_n59 dataIn_NORTH[0] AOI22X1TS
XU1754 n1526 n34 cacheDataOut[1] FE_DBTN69_n1527 dataoutbuffer[7][1] AOI22X1TS
XU1755 n1525 FE_DBTN68_n55 dataIn_WEST[1] n32 dataIn_EAST[1] AOI22X1TS
XU1756 n1524 n51 dataIn_SOUTH[1] FE_DBTN70_n59 dataIn_NORTH[1] AOI22X1TS
XU1758 n1534 n34 cacheDataOut[2] FE_DBTN69_n1527 dataoutbuffer[7][2] AOI22X1TS
XU1759 n1533 FE_DBTN68_n55 dataIn_WEST[2] n32 dataIn_EAST[2] AOI22X1TS
XU1760 n1532 n51 dataIn_SOUTH[2] FE_DBTN70_n59 dataIn_NORTH[2] AOI22X1TS
XU1761 n1542 n34 cacheDataOut[3] FE_DBTN69_n1527 dataoutbuffer[7][3] AOI22X1TS
XU1762 n1541 FE_DBTN68_n55 dataIn_WEST[3] n32 dataIn_EAST[3] AOI22X1TS
XU1763 n1540 n51 dataIn_SOUTH[3] FE_DBTN70_n59 dataIn_NORTH[3] AOI22X1TS
XU1764 n1552 n34 cacheDataOut[4] FE_DBTN69_n1527 dataoutbuffer[7][4] AOI22X1TS
XU1765 n1551 FE_DBTN68_n55 dataIn_WEST[4] n32 dataIn_EAST[4] AOI22X1TS
XU1766 n1550 n51 dataIn_SOUTH[4] FE_DBTN70_n59 dataIn_NORTH[4] AOI22X1TS
XU1767 n1561 n34 cacheDataOut[5] FE_DBTN69_n1527 dataoutbuffer[7][5] AOI22X1TS
XU1768 n1560 FE_DBTN68_n55 dataIn_WEST[5] n32 dataIn_EAST[5] AOI22X1TS
XU1769 n1559 n51 dataIn_SOUTH[5] FE_DBTN70_n59 dataIn_NORTH[5] AOI22X1TS
XU1772 n1566 n1564 readIn_SOUTH readIn_NORTH n1563 AOI22X1TS
XU1773 n1569 n1567 FE_DBTN215_readInBuffer_EAST n1566 n1565 AOI22X1TS
XU1774 n1573 n1570 readIn_WEST n1569 n1568 AOI22X1TS
XU1775 n2066 n1573 n1527 n1571 FE_DBTN69_n1527 n1939 AOI32X1TS
XU1777 n1577 n1575 readIn_SOUTH readIn_NORTH n1574 AOI22X1TS
XU1778 n1580 n1578 FE_DBTN215_readInBuffer_EAST n1577 n1576 AOI22X1TS
XU1779 n1584 n1581 readIn_WEST n1580 n1579 AOI22X1TS
XU1780 n2067 n1584 n1475 n1582 FE_DBTN66_n1475 n1940 AOI32X1TS
XU1781 n1590 n1588 readIn_SOUTH readIn_NORTH n1585 AOI22X1TS
XU1782 n1593 n1591 FE_DBTN215_readInBuffer_EAST n1590 n1589 AOI22X1TS
XU1783 n1597 n1594 readIn_WEST n1593 n1592 AOI22X1TS
XU1784 n2068 n1597 n1438 n1595 FE_DBTN57_n1438 n1941 AOI32X1TS
XU1786 n1601 n1599 readIn_SOUTH readIn_NORTH n1598 AOI22X1TS
XU1787 n1604 n1602 FE_DBTN215_readInBuffer_EAST n1601 n1600 AOI22X1TS
XU1788 n1609 n1606 readIn_WEST n1604 n1603 AOI22X1TS
XU1789 n2069 n1609 n1406 n1607 FE_DBTN54_n1406 n1942 AOI32X1TS
XU1790 n1611 n123 readIn_SOUTH readIn_NORTH n26 AOI22X1TS
XU1791 n1614 n1612 FE_DBTN215_readInBuffer_EAST n1611 n1610 AOI22X1TS
XU1792 n1618 n1615 readIn_WEST n1614 n1613 AOI22X1TS
XU1793 n2070 n1618 n1377 n1616 FE_DBTN63_n1377 n1943 AOI32X1TS
XU1794 n1623 n1621 readIn_SOUTH readIn_NORTH n1619 AOI22X1TS
XU1795 n1627 n1625 FE_DBTN215_readInBuffer_EAST n1623 n1622 AOI22X1TS
XU1796 n1631 n1628 readIn_WEST n1627 n1626 AOI22X1TS
XU1797 n2071 n1631 n1343 n1629 FE_DBTN60_n1343 n1944 AOI32X1TS
XU1798 n1636 n1634 readIn_SOUTH readIn_NORTH n1632 AOI22X1TS
XU1799 n1639 n1637 FE_DBTN215_readInBuffer_EAST n1636 n1635 AOI22X1TS
XU1800 n1643 n1641 readIn_WEST n1639 n1638 AOI22X1TS
XU1801 n2072 n1643 n354 n1642 FE_DBTN52_n354 n1945 AOI32X1TS
XU1802 n1648 n1646 readIn_SOUTH readIn_NORTH n1644 AOI22X1TS
XU1803 n1652 n1650 FE_DBTN215_readInBuffer_EAST n1648 n1647 AOI22X1TS
XU1804 n1656 n1654 readIn_WEST n1652 n1651 AOI22X1TS
XU1805 n2073 n1656 n422 n1655 FE_DBTN49_n422 n1946 AOI32X1TS
XU1806 n1662 readRequesterAddress[0] n34 FE_DBTN69_n1527
+ destinationAddressbuffer[7][0] AOI22X1TS
XU1807 n1661 FE_DBTN68_n55 destinationAddressIn_WEST[0] n32
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1809 n1660 n51 destinationAddressIn_SOUTH[0] FE_DBTN70_n59
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1810 n1669 n34 readRequesterAddress[1] FE_DBTN69_n1527
+ destinationAddressbuffer[7][1] AOI22X1TS
XU1811 n1668 FE_DBTN68_n55 destinationAddressIn_WEST[1] n32
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1813 n1667 n51 destinationAddressIn_SOUTH[1] FE_DBTN70_n59
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1814 n1677 n34 readRequesterAddress[2] FE_DBTN69_n1527
+ destinationAddressbuffer[7][2] AOI22X1TS
XU1815 n1676 FE_DBTN68_n55 destinationAddressIn_WEST[2] n32
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1817 n1675 n51 destinationAddressIn_SOUTH[2] FE_DBTN70_n59
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1818 n1685 n34 readRequesterAddress[3] FE_DBTN69_n1527
+ destinationAddressbuffer[7][3] AOI22X1TS
XU1819 n1684 FE_DBTN68_n55 destinationAddressIn_WEST[3] n32
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1821 n1683 n51 destinationAddressIn_SOUTH[3] FE_DBTN70_n59
+ destinationAddressIn_NORTH[3] AOI22X1TS
XU1822 n1689 readRequesterAddress[0] n86 FE_DBTN66_n1475
+ destinationAddressbuffer[6][0] AOI22X1TS
XU1823 n1688 FE_DBTN65_n106 destinationAddressIn_WEST[0] n84
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1827 n1687 FE_DBTN77_n5 destinationAddressIn_NORTH[0] n92
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1828 n1697 readRequesterAddress[1] n86 FE_DBTN66_n1475
+ destinationAddressbuffer[6][1] AOI22X1TS
XU1829 n1696 FE_DBTN65_n106 destinationAddressIn_WEST[1] n84
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1833 n1695 FE_DBTN77_n5 destinationAddressIn_NORTH[1] n92
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1834 n1704 readRequesterAddress[2] n86 FE_DBTN66_n1475
+ destinationAddressbuffer[6][2] AOI22X1TS
XU1835 n1703 FE_DBTN65_n106 destinationAddressIn_WEST[2] n84
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1839 n1702 FE_DBTN77_n5 destinationAddressIn_NORTH[2] n92
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1840 n1710 readRequesterAddress[3] n86 FE_DBTN66_n1475
+ destinationAddressbuffer[6][3] AOI22X1TS
XU1841 n1709 FE_DBTN65_n106 destinationAddressIn_WEST[3] n84
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1845 n1708 FE_DBTN77_n5 destinationAddressIn_NORTH[3] n92
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1846 n1717 readRequesterAddress[0] n222 FE_DBTN57_n1438
+ destinationAddressbuffer[5][0] AOI22X1TS
XU1847 n1716 FE_DBTN59_n239 destinationAddressIn_WEST[0] n221
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1848 n1715 FE_DBTN81_n1 destinationAddressIn_NORTH[0] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1849 n1726 readRequesterAddress[1] n222 FE_DBTN57_n1438
+ destinationAddressbuffer[5][1] AOI22X1TS
XU1850 n1725 FE_DBTN59_n239 destinationAddressIn_WEST[1] n221
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1851 n1724 FE_DBTN81_n1 destinationAddressIn_NORTH[1] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1852 n1735 readRequesterAddress[2] n222 FE_DBTN57_n1438
+ destinationAddressbuffer[5][2] AOI22X1TS
XU1853 n1734 FE_DBTN59_n239 destinationAddressIn_WEST[2] n221
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1854 n1733 FE_DBTN81_n1 destinationAddressIn_NORTH[2] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1855 n1743 readRequesterAddress[3] n222 FE_DBTN57_n1438
+ destinationAddressbuffer[5][3] AOI22X1TS
XU1856 n1742 FE_DBTN59_n239 destinationAddressIn_WEST[3] n221
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1857 n1741 FE_DBTN81_n1 destinationAddressIn_NORTH[3] FE_DBTN58_n245
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1858 n1748 readRequesterAddress[0] n274 FE_DBTN54_n1406
+ destinationAddressbuffer[4][0] AOI22X1TS
XU1859 n1747 FE_DBTN55_n289 destinationAddressIn_WEST[0] n272
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1860 n1746 FE_DBTN80_n2 destinationAddressIn_SOUTH[0] FE_DBTN75_n7
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1861 n1756 readRequesterAddress[1] n274 FE_DBTN54_n1406
+ destinationAddressbuffer[4][1] AOI22X1TS
XU1862 n1755 FE_DBTN55_n289 destinationAddressIn_WEST[1] n272
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1863 n1754 FE_DBTN80_n2 destinationAddressIn_SOUTH[1] FE_DBTN75_n7
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1864 n1766 readRequesterAddress[2] n274 FE_DBTN54_n1406
+ destinationAddressbuffer[4][2] AOI22X1TS
XU1865 n1765 FE_DBTN55_n289 destinationAddressIn_WEST[2] n272
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1866 n1764 FE_DBTN80_n2 destinationAddressIn_SOUTH[2] FE_DBTN75_n7
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1867 n1772 readRequesterAddress[3] n274 FE_DBTN54_n1406
+ destinationAddressbuffer[4][3] AOI22X1TS
XU1868 n1771 FE_DBTN55_n289 destinationAddressIn_WEST[3] n272
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1869 n1770 FE_DBTN80_n2 destinationAddressIn_SOUTH[3] FE_DBTN75_n7
+ destinationAddressIn_NORTH[3] AOI22X1TS
XU1870 n1778 readRequesterAddress[0] n134 FE_DBTN63_n1377
+ destinationAddressbuffer[3][0] AOI22X1TS
XU1871 n1777 FE_DBTN76_n6 destinationAddressIn_WEST[0] n141
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1872 n1776 FE_DBTN62_n163 destinationAddressIn_NORTH[0] n132
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1873 n1785 readRequesterAddress[1] n134 FE_DBTN63_n1377
+ destinationAddressbuffer[3][1] AOI22X1TS
XU1874 n1784 FE_DBTN76_n6 destinationAddressIn_WEST[1] n141
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1875 n1783 FE_DBTN62_n163 destinationAddressIn_NORTH[1] n132
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1876 n1792 readRequesterAddress[2] n134 FE_DBTN63_n1377
+ destinationAddressbuffer[3][2] AOI22X1TS
XU1877 n1791 FE_DBTN76_n6 destinationAddressIn_WEST[2] n141
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1878 n1790 FE_DBTN62_n163 destinationAddressIn_NORTH[2] n132
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1879 n1801 readRequesterAddress[3] n134 FE_DBTN63_n1377
+ destinationAddressbuffer[3][3] AOI22X1TS
XU1880 n1800 FE_DBTN76_n6 destinationAddressIn_WEST[3] n141
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1881 n1799 FE_DBTN62_n163 destinationAddressIn_NORTH[3] n132
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1882 n1806 readRequesterAddress[0] FE_DBTN72_n11 FE_DBTN60_n1343
+ destinationAddressbuffer[2][0] AOI22X1TS
XU1883 n1805 FE_DBTN61_n197 destinationAddressIn_WEST[0] n180
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1884 n1804 n199 destinationAddressIn_NORTH[0] n186
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1885 n1813 readRequesterAddress[1] FE_DBTN72_n11 FE_DBTN60_n1343
+ destinationAddressbuffer[2][1] AOI22X1TS
XU1886 n1812 FE_DBTN61_n197 destinationAddressIn_WEST[1] n180
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1887 n1811 n199 destinationAddressIn_NORTH[1] n186
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1888 n1820 readRequesterAddress[2] FE_DBTN72_n11 FE_DBTN60_n1343
+ destinationAddressbuffer[2][2] AOI22X1TS
XU1889 n1819 FE_DBTN61_n197 destinationAddressIn_WEST[2] n180
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1890 n1818 n199 destinationAddressIn_NORTH[2] n186
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1891 n1827 readRequesterAddress[3] FE_DBTN72_n11 FE_DBTN60_n1343
+ destinationAddressbuffer[2][3] AOI22X1TS
XU1892 n1826 FE_DBTN61_n197 destinationAddressIn_WEST[3] n180
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1893 n1825 n199 destinationAddressIn_NORTH[3] n186
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1894 n1836 readRequesterAddress[0] n315 FE_DBTN52_n354
+ destinationAddressbuffer[1][0] AOI22X1TS
XU1895 n1835 FE_DBTN53_n341 destinationAddressIn_WEST[0] n313
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1896 n1834 FE_DBTN78_n4 destinationAddressIn_NORTH[0] n322
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1897 n1848 readRequesterAddress[1] n315 FE_DBTN52_n354
+ destinationAddressbuffer[1][1] AOI22X1TS
XU1898 n1847 FE_DBTN53_n341 destinationAddressIn_WEST[1] n313
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1899 n1846 FE_DBTN78_n4 destinationAddressIn_NORTH[1] n322
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1900 n1860 readRequesterAddress[2] n315 FE_DBTN52_n354
+ destinationAddressbuffer[1][2] AOI22X1TS
XU1901 n1859 FE_DBTN53_n341 destinationAddressIn_WEST[2] n313
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1902 n1858 FE_DBTN78_n4 destinationAddressIn_NORTH[2] n322
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1903 n1869 readRequesterAddress[3] n315 FE_DBTN52_n354
+ destinationAddressbuffer[1][3] AOI22X1TS
XU1904 n1868 FE_DBTN53_n341 destinationAddressIn_WEST[3] n313
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1905 n1867 FE_DBTN78_n4 destinationAddressIn_NORTH[3] n322
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1906 n1877 readRequesterAddress[0] FE_DBTN71_n12 FE_DBTN49_n422
+ destinationAddressbuffer[0][0] AOI22X1TS
XU1907 n1876 FE_DBTN48_n416 destinationAddressIn_WEST[0] n390
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1908 n1875 FE_DBTN79_n3 destinationAddressIn_SOUTH[0] FE_DBTN74_n8
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1909 n1887 readRequesterAddress[1] FE_DBTN71_n12 FE_DBTN49_n422
+ destinationAddressbuffer[0][1] AOI22X1TS
XU1910 n1886 FE_DBTN48_n416 destinationAddressIn_WEST[1] n390
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1911 n1885 FE_DBTN79_n3 destinationAddressIn_SOUTH[1] FE_DBTN74_n8
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1912 n1899 readRequesterAddress[2] FE_DBTN71_n12 FE_DBTN49_n422
+ destinationAddressbuffer[0][2] AOI22X1TS
XU1913 n1898 FE_DBTN48_n416 destinationAddressIn_WEST[2] n390
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1914 n1897 FE_DBTN79_n3 destinationAddressIn_SOUTH[2] FE_DBTN74_n8
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1915 n1908 readRequesterAddress[3] FE_DBTN71_n12 FE_DBTN49_n422
+ destinationAddressbuffer[0][3] AOI22X1TS
XU1916 n1907 FE_DBTN48_n416 destinationAddressIn_WEST[3] n390
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1917 n1906 FE_DBTN79_n3 destinationAddressIn_SOUTH[3] FE_DBTN74_n8
+ destinationAddressIn_NORTH[3] AOI22X1TS
.ENDS

.SUBCKT outputPortArbiter_3 clk reset selectBit_NORTH
+ destinationAddressIn_NORTH[11] destinationAddressIn_NORTH[10]
+ destinationAddressIn_NORTH[9] destinationAddressIn_NORTH[8]
+ destinationAddressIn_NORTH[7] destinationAddressIn_NORTH[6]
+ destinationAddressIn_NORTH[5] destinationAddressIn_NORTH[4]
+ destinationAddressIn_NORTH[3] destinationAddressIn_NORTH[2]
+ destinationAddressIn_NORTH[1] destinationAddressIn_NORTH[0]
+ requesterAddressIn_NORTH[3] requesterAddressIn_NORTH[2]
+ requesterAddressIn_NORTH[1] requesterAddressIn_NORTH[0] readIn_NORTH
+ writeIn_NORTH dataIn_NORTH[5] dataIn_NORTH[4] dataIn_NORTH[3] dataIn_NORTH[2]
+ dataIn_NORTH[1] dataIn_NORTH[0] selectBit_SOUTH
+ destinationAddressIn_SOUTH[11] destinationAddressIn_SOUTH[10]
+ destinationAddressIn_SOUTH[9] destinationAddressIn_SOUTH[8]
+ destinationAddressIn_SOUTH[7] destinationAddressIn_SOUTH[6]
+ destinationAddressIn_SOUTH[5] destinationAddressIn_SOUTH[4]
+ destinationAddressIn_SOUTH[3] destinationAddressIn_SOUTH[2]
+ destinationAddressIn_SOUTH[1] destinationAddressIn_SOUTH[0]
+ requesterAddressIn_SOUTH[3] requesterAddressIn_SOUTH[2]
+ requesterAddressIn_SOUTH[1] requesterAddressIn_SOUTH[0] readIn_SOUTH
+ writeIn_SOUTH dataIn_SOUTH[5] dataIn_SOUTH[4] dataIn_SOUTH[3] dataIn_SOUTH[2]
+ dataIn_SOUTH[1] dataIn_SOUTH[0] selectBit_EAST destinationAddressIn_EAST[11]
+ destinationAddressIn_EAST[10] destinationAddressIn_EAST[9]
+ destinationAddressIn_EAST[8] destinationAddressIn_EAST[7]
+ destinationAddressIn_EAST[6] destinationAddressIn_EAST[5]
+ destinationAddressIn_EAST[4] destinationAddressIn_EAST[3]
+ destinationAddressIn_EAST[2] destinationAddressIn_EAST[1]
+ destinationAddressIn_EAST[0] requesterAddressIn_EAST[3]
+ requesterAddressIn_EAST[2] requesterAddressIn_EAST[1]
+ requesterAddressIn_EAST[0] readIn_EAST writeIn_EAST dataIn_EAST[5]
+ dataIn_EAST[4] dataIn_EAST[3] dataIn_EAST[2] dataIn_EAST[1] dataIn_EAST[0]
+ selectBit_WEST destinationAddressIn_WEST[11] destinationAddressIn_WEST[10]
+ destinationAddressIn_WEST[9] destinationAddressIn_WEST[8]
+ destinationAddressIn_WEST[7] destinationAddressIn_WEST[6]
+ destinationAddressIn_WEST[5] destinationAddressIn_WEST[4]
+ destinationAddressIn_WEST[3] destinationAddressIn_WEST[2]
+ destinationAddressIn_WEST[1] destinationAddressIn_WEST[0]
+ requesterAddressIn_WEST[3] requesterAddressIn_WEST[2]
+ requesterAddressIn_WEST[1] requesterAddressIn_WEST[0] readIn_WEST
+ writeIn_WEST dataIn_WEST[5] dataIn_WEST[4] dataIn_WEST[3] dataIn_WEST[2]
+ dataIn_WEST[1] dataIn_WEST[0] readReady readRequesterAddress[3]
+ readRequesterAddress[2] readRequesterAddress[1] readRequesterAddress[0]
+ cacheDataOut[5] cacheDataOut[4] cacheDataOut[3] cacheDataOut[2]
+ cacheDataOut[1] cacheDataOut[0] destinationAddressOut[11]
+ destinationAddressOut[10] destinationAddressOut[9] destinationAddressOut[8]
+ destinationAddressOut[7] destinationAddressOut[6] destinationAddressOut[5]
+ destinationAddressOut[4] destinationAddressOut[3] destinationAddressOut[2]
+ destinationAddressOut[1] destinationAddressOut[0] requesterAddressOut[3]
+ requesterAddressOut[2] requesterAddressOut[1] requesterAddressOut[0] readOut
+ writeOut dataOut[5] dataOut[4] dataOut[3] dataOut[2] dataOut[1] dataOut[0]
XFE_DBTC218_readInBuffer_EAST FE_DBTN218_readInBuffer_EAST readIn_EAST INVX2TS
XFE_DBTC124_n1 FE_DBTN124_n1 n1 INVX2TS
XFE_DBTC123_n2 FE_DBTN123_n2 n2 INVX2TS
XFE_DBTC122_n3 FE_DBTN122_n3 n3 INVX2TS
XFE_DBTC121_n4 FE_DBTN121_n4 n4 INVX2TS
XFE_DBTC120_n5 FE_DBTN120_n5 n5 INVX2TS
XFE_DBTC119_n6 FE_DBTN119_n6 n6 INVX2TS
XFE_DBTC118_n7 FE_DBTN118_n7 n7 INVX2TS
XFE_DBTC117_n8 FE_DBTN117_n8 n8 INVX2TS
XFE_DBTC116_n10 FE_DBTN116_n10 n10 INVX2TS
XFE_DBTC115_n11 FE_DBTN115_n11 n11 INVX2TS
XFE_DBTC114_n12 FE_DBTN114_n12 n12 INVX2TS
XFE_DBTC113_n13 FE_DBTN113_n13 n13 INVX2TS
XFE_DBTC112_n14 FE_DBTN112_n14 n14 INVX2TS
XFE_DBTC111_n50 FE_DBTN111_n50 n50 INVX2TS
XFE_DBTC110_n1533 FE_DBTN110_n1533 n1533 INVX2TS
XFE_DBTC109_n62 FE_DBTN109_n62 n62 INVX2TS
XFE_DBTC108_n1946 FE_DBTN108_n1946 n1946 INVX2TS
XFE_DBTC107_n96 FE_DBTN107_n96 n96 INVX2TS
XFE_DBTC106_n1479 FE_DBTN106_n1479 n1479 INVX2TS
XFE_DBTC105_n1384 FE_DBTN105_n1384 n1384 INVX2TS
XFE_DBTC104_n159 FE_DBTN104_n159 n159 INVX2TS
XFE_DBTC103_n191 FE_DBTN103_n191 n191 INVX2TS
XFE_DBTC102_n1352 FE_DBTN102_n1352 n1352 INVX2TS
XFE_DBTC101_n214 FE_DBTN101_n214 n214 INVX2TS
XFE_DBTC100_n235 FE_DBTN100_n235 n235 INVX2TS
XFE_DBTC99_n253 FE_DBTN99_n253 n253 INVX2TS
XFE_DBTC98_n1444 FE_DBTN98_n1444 n1444 INVX2TS
XFE_DBTC97_n1944 FE_DBTN97_n1944 n1944 INVX2TS
XFE_DBTC96_n285 FE_DBTN96_n285 n285 INVX2TS
XFE_DBTC95_n1413 FE_DBTN95_n1413 n1413 INVX2TS
XFE_DBTC94_n334 FE_DBTN94_n334 n334 INVX2TS
XFE_DBTC93_n347 FE_DBTN93_n347 n347 INVX2TS
XFE_DBTC92_n1941 FE_DBTN92_n1941 n1941 INVX2TS
XFE_DBTC91_n1938 FE_DBTN91_n1938 n1938 INVX2TS
XFE_DBTC90_n419 FE_DBTN90_n419 n419 INVX2TS
XFE_DBTC89_n412 FE_DBTN89_n412 n412 INVX2TS
XFE_DBTC88_n1943 FE_DBTN88_n1943 n1943 INVX2TS
XFE_DBTC87_n1942 FE_DBTN87_n1942 n1942 INVX2TS
XFE_DBTC86_n673 FE_DBTN86_n673 n673 INVX2TS
XFE_DBTC85_n1945 FE_DBTN85_n1945 n1945 INVX2TS
XFE_DBTC84_n1937 FE_DBTN84_n1937 n1937 INVX2TS
XFE_DBTC83_n1936 FE_DBTN83_n1936 n1936 INVX2TS
XFE_DBTC82_n559 FE_DBTN82_n559 n559 INVX2TS
Xfull_reg_reg 1000 n1947 clk N2624 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][0] requesterAddressbuffer[2][0] 1001 clk n2007
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][1] requesterAddressbuffer[2][1] 1002 clk n2008
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][2] requesterAddressbuffer[2][2] 1003 clk n2009
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[2][3] requesterAddressbuffer[2][3] 1004 clk n2010
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][0] destinationAddressbuffer[2][0] 1005 clk
+ n2143 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][1] destinationAddressbuffer[2][1] 1006 clk
+ n2144 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][2] destinationAddressbuffer[2][2] 1007 clk
+ n2145 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][3] destinationAddressbuffer[2][3] 1008 clk
+ n2146 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][0] dataoutbuffer[0][0] 1009 clk n2019 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][1] dataoutbuffer[0][1] 1010 clk n2020 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][2] dataoutbuffer[0][2] 1011 clk n2021 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][3] dataoutbuffer[0][3] 1012 clk n2022 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][4] dataoutbuffer[0][4] 1013 clk n2023 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[0][5] dataoutbuffer[0][5] 1014 clk n2024 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[7] writeOutbuffer[7] 1015 clk n2067 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][4] destinationAddressbuffer[7][4] 1016 clk
+ n2087 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][5] destinationAddressbuffer[7][5] 1017 clk
+ n2088 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][6] destinationAddressbuffer[7][6] 1018 clk
+ n2089 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][7] destinationAddressbuffer[7][7] 1019 clk
+ n2090 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][8] destinationAddressbuffer[7][8] 1020 clk
+ n2091 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][9] destinationAddressbuffer[7][9] 1021 clk
+ n2092 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][11] destinationAddressbuffer[7][11] 1022 clk
+ n2094 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[6] writeOutbuffer[6] 1023 clk n2068 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][4] destinationAddressbuffer[6][4] 1024 clk
+ n2099 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][5] destinationAddressbuffer[6][5] 1025 clk
+ n2100 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][6] destinationAddressbuffer[6][6] 1026 clk
+ n2101 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][7] destinationAddressbuffer[6][7] 1027 clk
+ n2102 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][8] destinationAddressbuffer[6][8] 1028 clk
+ n2103 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][9] destinationAddressbuffer[6][9] 1029 clk
+ n2104 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][10] destinationAddressbuffer[6][10] 1030 clk
+ n2105 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][11] destinationAddressbuffer[6][11] 1031 clk
+ n2106 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[3] writeOutbuffer[3] 1032 clk n2071 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][4] destinationAddressbuffer[3][4] 1033 clk
+ n2135 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][5] destinationAddressbuffer[3][5] 1034 clk
+ n2136 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][6] destinationAddressbuffer[3][6] 1035 clk
+ n2137 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][7] destinationAddressbuffer[3][7] 1036 clk
+ n2138 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][8] destinationAddressbuffer[3][8] 1037 clk
+ n2139 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][9] destinationAddressbuffer[3][9] 1038 clk
+ n2140 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][10] destinationAddressbuffer[3][10] 1039 clk
+ n2141 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][11] destinationAddressbuffer[3][11] 1040 clk
+ n2142 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[2] writeOutbuffer[2] 1041 clk n2072 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][4] destinationAddressbuffer[2][4] 1042 clk
+ n2147 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][5] destinationAddressbuffer[2][5] 1043 clk
+ n2148 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][6] destinationAddressbuffer[2][6] 1044 clk
+ n2149 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][7] destinationAddressbuffer[2][7] 1045 clk
+ n2150 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][8] destinationAddressbuffer[2][8] 1046 clk
+ n2151 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][9] destinationAddressbuffer[2][9] 1047 clk
+ n2152 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][10] destinationAddressbuffer[2][10] 1048 clk
+ n2153 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[2][11] destinationAddressbuffer[2][11] 1049 clk
+ n2154 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][0] dataoutbuffer[7][0] 1050 clk n2061 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][1] dataoutbuffer[7][1] 1051 clk n2062 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][2] dataoutbuffer[7][2] 1052 clk n2063 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][3] dataoutbuffer[7][3] 1053 clk n2064 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][4] dataoutbuffer[7][4] 1054 clk n2065 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[7][5] dataoutbuffer[7][5] 1055 clk n2066 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][0] dataoutbuffer[6][0] 1056 clk n2055 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][1] dataoutbuffer[6][1] 1057 clk n2056 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][2] dataoutbuffer[6][2] 1058 clk n2057 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][3] dataoutbuffer[6][3] 1059 clk n2058 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][4] dataoutbuffer[6][4] 1060 clk n2059 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[6][5] dataoutbuffer[6][5] 1061 clk n2060 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][0] requesterAddressbuffer[5][0] 1062 clk n1995
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][1] requesterAddressbuffer[5][1] 1063 clk n1996
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][2] requesterAddressbuffer[5][2] 1064 clk n1997
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[5][3] requesterAddressbuffer[5][3] 1065 clk n1998
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][0] destinationAddressbuffer[5][0] 1066 clk
+ n2107 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][1] destinationAddressbuffer[5][1] 1067 clk
+ n2108 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][2] destinationAddressbuffer[5][2] 1068 clk
+ n2109 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][3] destinationAddressbuffer[5][3] 1069 clk
+ n2110 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][0] requesterAddressbuffer[4][0] 1070 clk n1999
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][1] requesterAddressbuffer[4][1] 1071 clk n2000
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][2] requesterAddressbuffer[4][2] 1072 clk n2001
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[4][3] requesterAddressbuffer[4][3] 1073 clk n2002
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][0] destinationAddressbuffer[4][0] 1074 clk
+ n2119 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][1] destinationAddressbuffer[4][1] 1075 clk
+ n2120 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][2] destinationAddressbuffer[4][2] 1076 clk
+ n2121 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][3] destinationAddressbuffer[4][3] 1077 clk
+ n2122 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][0] dataoutbuffer[3][0] 1078 clk n2037 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][1] dataoutbuffer[3][1] 1079 clk n2038 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][2] dataoutbuffer[3][2] 1080 clk n2039 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][3] dataoutbuffer[3][3] 1081 clk n2040 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][4] dataoutbuffer[3][4] 1082 clk n2041 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[3][5] dataoutbuffer[3][5] 1083 clk n2042 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][0] dataoutbuffer[2][0] 1084 clk n2031 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][1] dataoutbuffer[2][1] 1085 clk n2032 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][2] dataoutbuffer[2][2] 1086 clk n2033 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][3] dataoutbuffer[2][3] 1087 clk n2034 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][4] dataoutbuffer[2][4] 1088 clk n2035 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[2][5] dataoutbuffer[2][5] 1089 clk n2036 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][0] requesterAddressbuffer[1][0] 1090 clk n2011
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][1] requesterAddressbuffer[1][1] 1091 clk n2012
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][2] requesterAddressbuffer[1][2] 1092 clk n2013
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[1][3] requesterAddressbuffer[1][3] 1093 clk n2014
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][0] destinationAddressbuffer[1][0] 1094 clk
+ n2155 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][1] destinationAddressbuffer[1][1] 1095 clk
+ n2156 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][2] destinationAddressbuffer[1][2] 1096 clk
+ n2157 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][3] destinationAddressbuffer[1][3] 1097 clk
+ n2158 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][0] requesterAddressbuffer[0][0] 1098 clk n2015
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][1] requesterAddressbuffer[0][1] 1099 clk n2016
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][2] requesterAddressbuffer[0][2] 1100 clk n2017
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[0][3] requesterAddressbuffer[0][3] 1101 clk n2018
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][0] destinationAddressbuffer[0][0] 1102 clk
+ n2167 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][1] destinationAddressbuffer[0][1] 1103 clk
+ n2168 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][2] destinationAddressbuffer[0][2] 1104 clk
+ n2169 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][3] destinationAddressbuffer[0][3] 1105 clk
+ n2170 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][0] requesterAddressbuffer[7][0] 1106 clk n1987
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][1] requesterAddressbuffer[7][1] 1107 clk n1988
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][2] requesterAddressbuffer[7][2] 1108 clk n1989
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[7][3] requesterAddressbuffer[7][3] 1109 clk n1990
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][0] destinationAddressbuffer[7][0] 1110 clk
+ n2083 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][1] destinationAddressbuffer[7][1] 1111 clk
+ n2084 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][2] destinationAddressbuffer[7][2] 1112 clk
+ n2085 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][3] destinationAddressbuffer[7][3] 1113 clk
+ n2086 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][0] requesterAddressbuffer[6][0] 1114 clk n1991
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][1] requesterAddressbuffer[6][1] 1115 clk n1992
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][2] requesterAddressbuffer[6][2] 1116 clk n1993
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[6][3] requesterAddressbuffer[6][3] 1117 clk n1994
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][0] destinationAddressbuffer[6][0] 1118 clk
+ n2095 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][1] destinationAddressbuffer[6][1] 1119 clk
+ n2096 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][2] destinationAddressbuffer[6][2] 1120 clk
+ n2097 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[6][3] destinationAddressbuffer[6][3] 1121 clk
+ n2098 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][0] dataoutbuffer[5][0] 1122 clk n2049 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][1] dataoutbuffer[5][1] 1123 clk n2050 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][2] dataoutbuffer[5][2] 1124 clk n2051 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][3] dataoutbuffer[5][3] 1125 clk n2052 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][4] dataoutbuffer[5][4] 1126 clk n2053 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[5][5] dataoutbuffer[5][5] 1127 clk n2054 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][0] dataoutbuffer[4][0] 1128 clk n2043 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][1] dataoutbuffer[4][1] 1129 clk n2044 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][2] dataoutbuffer[4][2] 1130 clk n2045 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][3] dataoutbuffer[4][3] 1131 clk n2046 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][4] dataoutbuffer[4][4] 1132 clk n2047 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[4][5] dataoutbuffer[4][5] 1133 clk n2048 VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][0] requesterAddressbuffer[3][0] 1134 clk n2003
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][1] requesterAddressbuffer[3][1] 1135 clk n2004
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][2] requesterAddressbuffer[3][2] 1136 clk n2005
+ VDD VDD DFFNSRX1TS
XrequesterAddressbuffer_reg[3][3] requesterAddressbuffer[3][3] 1137 clk n2006
+ VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][0] destinationAddressbuffer[3][0] 1138 clk
+ n2131 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][1] destinationAddressbuffer[3][1] 1139 clk
+ n2132 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][2] destinationAddressbuffer[3][2] 1140 clk
+ n2133 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[3][3] destinationAddressbuffer[3][3] 1141 clk
+ n2134 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][0] dataoutbuffer[1][0] 1142 clk n2025 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][1] dataoutbuffer[1][1] 1143 clk n2026 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][2] dataoutbuffer[1][2] 1144 clk n2027 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][3] dataoutbuffer[1][3] 1145 clk n2028 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][4] dataoutbuffer[1][4] 1146 clk n2029 VDD VDD DFFNSRX1TS
Xdataoutbuffer_reg[1][5] dataoutbuffer[1][5] 1147 clk n2030 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[5] writeOutbuffer[5] 1148 clk n2069 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][4] destinationAddressbuffer[5][4] 1149 clk
+ n2111 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][5] destinationAddressbuffer[5][5] 1150 clk
+ n2112 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][6] destinationAddressbuffer[5][6] 1151 clk
+ n2113 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][7] destinationAddressbuffer[5][7] 1152 clk
+ n2114 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][8] destinationAddressbuffer[5][8] 1153 clk
+ n2115 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][9] destinationAddressbuffer[5][9] 1154 clk
+ n2116 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][10] destinationAddressbuffer[5][10] 1155 clk
+ n2117 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[5][11] destinationAddressbuffer[5][11] 1156 clk
+ n2118 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[4] writeOutbuffer[4] 1157 clk n2070 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][4] destinationAddressbuffer[4][4] 1158 clk
+ n2123 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][5] destinationAddressbuffer[4][5] 1159 clk
+ n2124 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][6] destinationAddressbuffer[4][6] 1160 clk
+ n2125 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][7] destinationAddressbuffer[4][7] 1161 clk
+ n2126 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][8] destinationAddressbuffer[4][8] 1162 clk
+ n2127 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][9] destinationAddressbuffer[4][9] 1163 clk
+ n2128 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][10] destinationAddressbuffer[4][10] 1164 clk
+ n2129 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[4][11] destinationAddressbuffer[4][11] 1165 clk
+ n2130 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[1] writeOutbuffer[1] 1166 clk n2073 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][4] destinationAddressbuffer[1][4] 1167 clk
+ n2159 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][5] destinationAddressbuffer[1][5] 1168 clk
+ n2160 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][6] destinationAddressbuffer[1][6] 1169 clk
+ n2161 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][7] destinationAddressbuffer[1][7] 1170 clk
+ n2162 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][8] destinationAddressbuffer[1][8] 1171 clk
+ n2163 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][9] destinationAddressbuffer[1][9] 1172 clk
+ n2164 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][10] destinationAddressbuffer[1][10] 1173 clk
+ n2165 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[1][11] destinationAddressbuffer[1][11] 1174 clk
+ n2166 VDD VDD DFFNSRX1TS
XwriteOutbuffer_reg[0] writeOutbuffer[0] 1175 clk n2074 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][4] destinationAddressbuffer[0][4] 1176 clk
+ n2171 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][5] destinationAddressbuffer[0][5] 1177 clk
+ n2172 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][6] destinationAddressbuffer[0][6] 1178 clk
+ n2173 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][7] destinationAddressbuffer[0][7] 1179 clk
+ n2174 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][8] destinationAddressbuffer[0][8] 1180 clk
+ n2175 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][9] destinationAddressbuffer[0][9] 1181 clk
+ n2176 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][10] destinationAddressbuffer[0][10] 1182 clk
+ n2177 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[0][11] destinationAddressbuffer[0][11] 1183 clk
+ n2178 VDD VDD DFFNSRX1TS
XdestinationAddressbuffer_reg[7][10] destinationAddressbuffer[7][10] 1184 clk
+ n2093 VDD VDD DFFNSRX1TS
XwriteOut_reg writeOut 1185 clk n1964 VDD VDD DFFNSRX1TS
XdestinationAddressOut_reg[4] destinationAddressOut[4] 1186 clk n1973 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[5] destinationAddressOut[5] 1187 clk n1974 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[6] destinationAddressOut[6] 1188 clk n1975 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[7] destinationAddressOut[7] 1189 clk n1976 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[8] destinationAddressOut[8] 1190 clk n1977 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[9] destinationAddressOut[9] 1191 clk n1978 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[10] destinationAddressOut[10] 1192 clk n1979 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[11] destinationAddressOut[11] 1193 clk n1980 VDD VDD
+ DFFNSRX1TS
XreadOut_reg readOut 1194 clk n1963 VDD VDD DFFNSRX1TS
XrequesterAddressOut_reg[0] requesterAddressOut[0] 1195 clk n1965 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[1] requesterAddressOut[1] 1196 clk n1966 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[2] requesterAddressOut[2] 1197 clk n1967 VDD VDD
+ DFFNSRX1TS
XrequesterAddressOut_reg[3] requesterAddressOut[3] 1198 clk n1968 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[0] destinationAddressOut[0] 1199 clk n1969 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[1] destinationAddressOut[1] 1200 clk n1970 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[2] destinationAddressOut[2] 1201 clk n1971 VDD VDD
+ DFFNSRX1TS
XdestinationAddressOut_reg[3] destinationAddressOut[3] 1202 clk n1972 VDD VDD
+ DFFNSRX1TS
XdataOut_reg[0] dataOut[0] 1203 clk n1981 VDD VDD DFFNSRX1TS
XdataOut_reg[1] dataOut[1] 1204 clk n1982 VDD VDD DFFNSRX1TS
XdataOut_reg[2] dataOut[2] 1205 clk n1983 VDD VDD DFFNSRX1TS
XdataOut_reg[3] dataOut[3] 1206 clk n1984 VDD VDD DFFNSRX1TS
XdataOut_reg[4] dataOut[4] 1207 clk n1985 VDD VDD DFFNSRX1TS
XdataOut_reg[5] dataOut[5] 1208 clk n1986 VDD VDD DFFNSRX1TS
Xread_reg_reg[1] n1940 n1939 clk n1962 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[0] n1938 n1942 clk n1957 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[2] n1943 n1944 clk n1959 VDD VDD DFFNSRX1TS
Xread_reg_reg[0] n1933 n1945 clk n1956 VDD VDD DFFNSRX1TS
Xread_reg_reg[2] n1936 n1937 clk n1961 VDD VDD DFFNSRX1TS
Xempty_reg_reg n1935 n1934 clk n1960 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[7] readOutbuffer[7] n1948 clk n2075 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[4] readOutbuffer[4] n1951 clk n2078 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[5] readOutbuffer[5] n1950 clk n2077 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[6] readOutbuffer[6] n1949 clk n2076 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[1] readOutbuffer[1] n1954 clk n2081 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[2] readOutbuffer[2] n1953 clk n2080 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[0] readOutbuffer[0] n1955 clk n2082 VDD VDD DFFNSRX1TS
XreadOutbuffer_reg[3] readOutbuffer[3] n1952 clk n2079 VDD VDD DFFNSRX1TS
Xwrite_reg_reg[1] n1941 n1946 clk n1958 VDD VDD DFFNSRX1TS
XU4 n453 n467 n530 FE_DBTN92_n1941 n461 CMPR32X2TS
XU5 n463 n476 selectBit_WEST readReady n459 CMPR32X2TS
XU6 n464 n459 selectBit_SOUTH selectBit_NORTH selectBit_EAST CMPR32X2TS
XU8 n507 selectBit_WEST selectBit_EAST readReady NOR3XLTS
XU9 n93 n1577 n85 NOR2XLTS
XU10 n1614 n123 n374 NOR2XLTS
XU11 n1580 n375 n264 n263 NOR3XLTS
XU12 n1602 n1604 INVX2TS
XU13 n1591 n1593 INVX2TS
XU14 n1567 n1569 INVX2TS
XU15 n1630 n17 n176 n372 NOR3XLTS
XU16 n1596 n16 n73 n262 NOR3XLTS
XU18 n133 n1615 n132 NOR2XLTS
XU19 n310 FE_DBTN101_n214 n1644 NOR2XLTS
XU20 n129 FE_DBTN101_n214 n1618 NOR2XLTS
XU21 n270 FE_DBTN101_n214 n1609 NOR2XLTS
XU22 n216 n1596 n1591 n220 NOR3XLTS
XU23 n80 FE_DBTN101_n214 n1584 NOR2XLTS
XU24 n36 n1573 FE_DBTN101_n214 NOR2XLTS
XU25 n488 n490 FE_DBTN84_n1937 n487 OAI21XLTS
XU26 n491 n490 FE_DBTN84_n1937 n489 n488 AOI211XLTS
XU27 n86 n1576 n85 NOR2X1TS
XU28 n1094 n308 INVX2TS
XU29 n43 n1565 n40 NOR2X1TS
XU30 n85 n84 n83 NAND2BXLTS
XU31 n274 n273 n272 NAND2BXLTS
XU32 n183 n182 n181 NAND2BXLTS
XU33 n316 n314 n313 NAND2BXLTS
XU34 n387 n386 n385 NAND2BXLTS
XU35 n1569 n123 n264 NOR2X1TS
XU36 n374 n122 selectBit_EAST NAND2BX1TS
XU37 n489 FE_DBTN85_n1945 n493 XOR2XLTS
XU38 n479 n494 n486 FE_DBTN108_n1946 n484 ADDFX1TS
XU39 n1565 FE_DBTN108_n1946 n27 n213 NAND3X1TS
XU40 n1587 n27 n213 FE_DBTN117_n8 NAND3X1TS
XU41 n31 n9 FE_DBTN117_n8 NOR2X1TS
XU42 n305 n213 FE_DBTN117_n8 NOR2X1TS
XU43 n1640 n1643 INVX1TS
XU44 n372 n121 selectBit_WEST NAND2BX1TS
XU45 n214 n523 n1947 AND2X2TS
XU47 n19 n16 n464 FE_DBTN108_n1946 n18 ADDFX1TS
XU48 n1593 n306 n305 n264 NOR3X1TS
XU49 n504 selectBit_NORTH INVX2TS
XU50 n219 n1596 n1593 NOR2XLTS
XU51 n537 readReady selectBit_WEST selectBit_EAST NOR3BXLTS
XU52 n131 n132 n127 NAND2BXLTS
XU53 n132 n130 n1618 NAND2X1TS
XU54 n1413 n271 n270 OR2X1TS
XU55 n1444 n218 FE_DBTN113_n13 OR2X1TS
XU56 n1352 n179 FE_DBTN115_n11 OR2X1TS
XU57 n1384 n130 n129 OR2X1TS
XU58 n1479 n81 n80 OR2X1TS
XU59 n1533 n37 n36 OR2X1TS
XU60 n484 n478 n477 CLKAND2X2TS
XU61 n1618 FE_DBTN108_n1946 FE_DBTN87_n1942 readReady FE_DBTN88_n1943 NAND4XLTS
XU62 n1615 n1617 INVX2TS
XU64 n1656 n16 n17 n372 NOR3XLTS
XU65 n1649 n1652 INVX2TS
XU66 n1624 n1627 INVX2TS
XU68 n1644 FE_DBTN87_n1942 readReady FE_DBTN88_n1943 FE_DBTN92_n1941 NAND4XLTS
XU69 n1643 n16 n73 n372 NOR3XLTS
XU70 n1637 n1639 INVX2TS
XU71 n1584 FE_DBTN108_n1946 FE_DBTN97_n1944 readReady FE_DBTN91_n1938 NAND4XLTS
XU72 n1583 n17 n176 n262 NOR3XLTS
XU73 n1576 n1577 INVX2TS
XU74 n1578 n1580 INVX2TS
XU77 n1609 FE_DBTN97_n1944 readReady FE_DBTN91_n1938 FE_DBTN92_n1941 NAND4XLTS
XU78 n1608 n16 n17 n262 NOR3XLTS
XU80 n1573 n1938 FE_DBTN108_n1946 FE_DBTN97_n1944 readReady NAND4XLTS
XU82 n559 n538 n1935 n537 NAND3XLTS
XU83 n550 n523 FE_DBTN86_n673 CLKAND2X2TS
XU84 n272 n1608 n1604 NOR2XLTS
XU85 n38 n1572 n1569 NOR2XLTS
XU86 n181 n1630 n1627 NOR2XLTS
XU87 n385 n1656 n1652 NOR2XLTS
XU88 n313 n1643 n1639 NOR2XLTS
XU89 n24 FE_DBTN91_n1938 n504 n20 AO21X1TS
XU90 n122 n31 n26 n29 OAI21XLTS
XU91 n518 selectBit_NORTH n507 n506 NAND3XLTS
XU92 n517 selectBit_SOUTH n507 n504 NAND3XLTS
XU93 n127 n1617 n1614 NOR2XLTS
XU94 n83 n1583 n1580 NOR2XLTS
XU95 n222 n220 n219 NAND2BXLTS
XU96 n215 n20 FE_DBTN97_n1944 FE_DBTN92_n1941 NAND3XLTS
XU97 n40 n39 n38 NAND2BXLTS
XU98 n473 n453 n455 XOR2XLTS
XU99 n457 FE_DBTN108_n1946 n1939 n455 OAI21XLTS
XU101 n121 FE_DBTN97_n1944 n19 XOR2X1TS
XU102 n498 n214 reset NOR2XLTS
XU103 n1617 n176 n73 n372 NOR3X1TS
XU104 n1612 n1614 INVX2TS
XU105 n1657 readReady FE_DBTN91_n1938 FE_DBTN92_n1941 FE_DBTN88_n1943 NAND4XLTS
XU106 n1648 n27 n8 n23 NOR3XLTS
XU107 n1653 n1656 INVX2TS
XU108 n1646 n1648 INVX2TS
XU109 n1652 n375 n374 n263 NOR3BXLTS
XU110 n1631 FE_DBTN108_n1946 readReady FE_DBTN91_n1938 FE_DBTN88_n1943
+ NAND4XLTS
XU111 n1623 n27 n23 FE_DBTN117_n8 NOR3XLTS
XU112 n1628 n1630 INVX2TS
XU113 n1621 n1623 INVX2TS
XU114 n1636 n27 n8 n9 NOR3XLTS
XU115 n1634 n1636 INVX2TS
XU116 n1639 n306 n305 n374 NOR3XLTS
XU117 n1581 n1583 INVX2TS
XU118 n1597 FE_DBTN87_n1942 FE_DBTN97_n1944 readReady FE_DBTN92_n1941 NAND4XLTS
XU119 n1594 n1596 INVX2TS
XU120 n1590 n1587 INVX2TS
XU121 n1601 n8 n23 n26 NOR3XLTS
XU122 n1600 n1601 INVX2TS
XU123 n1605 n1608 INVX2TS
XU124 n1604 n375 n264 n263 NOR3BXLTS
XU125 n1570 n16 n17 n121 selectBit_WEST NAND4XLTS
XU126 n1566 n1565 INVX2TS
XU127 n137 destinationAddressIn_SOUTH[11] INVX2TS
XU128 n140 destinationAddressIn_SOUTH[10] INVX2TS
XU129 n145 destinationAddressIn_SOUTH[9] INVX2TS
XU130 n149 destinationAddressIn_SOUTH[8] INVX2TS
XU131 n483 n478 n476 CLKAND2X2TS
XU132 n1959 n1943 n498 n497 n496 AO22XLTS
XU133 n1957 n1938 n498 n497 n493 AO22XLTS
XU134 n1958 FE_DBTN108_n1946 n498 n497 n494 AO22XLTS
XU135 n1960 n214 n449 n492 OAI21XLTS
XU136 n1986 n872 n871 n870 n869 NAND4XLTS
XU137 n1985 n848 n847 n846 n845 NAND4XLTS
XU138 n1984 n836 n835 n834 n833 NAND4XLTS
XU139 n1983 n824 n823 n822 n821 NAND4XLTS
XU140 n1982 n805 n804 n803 n802 NAND4XLTS
XU141 n1981 n785 n784 n783 n782 NAND4XLTS
XU142 n1972 n655 n654 n653 n652 NAND4XLTS
XU143 n1971 n643 n642 n641 n640 NAND4XLTS
XU144 n1970 n624 n623 n622 n621 NAND4XLTS
XU145 n1969 n609 n608 n607 n606 NAND4XLTS
XU146 n1968 n598 n597 n596 n652 NAND4XLTS
XU147 n1967 n587 n586 n585 n640 NAND4XLTS
XU148 n1966 n579 n578 n577 n621 NAND4XLTS
XU149 n1965 n562 n561 n560 n606 NAND4XLTS
XU150 n1963 n541 n540 n539 n559 NAND4XLTS
XU151 n1980 n775 n774 n773 NAND3XLTS
XU152 n1979 n761 n760 n759 NAND3XLTS
XU153 n1978 n746 n745 n744 NAND3XLTS
XU154 n1977 n728 n727 n726 NAND3XLTS
XU155 n1976 n714 n713 n712 NAND3XLTS
XU156 n1975 n703 n702 n701 NAND3XLTS
XU157 n1974 n688 n687 n686 NAND3XLTS
XU158 n1973 n666 n665 n664 NAND3XLTS
XU159 n1964 n553 n552 n551 NAND3XLTS
XU160 n2030 n1342 n1341 n1340 NAND3XLTS
XU161 n2029 n1111 n1110 n1109 NAND3XLTS
XU162 n2028 n1106 n1105 n1104 NAND3XLTS
XU163 n2027 n1100 n1099 n1098 NAND3XLTS
XU164 n2026 n1091 n1090 n1089 NAND3XLTS
XU165 n2025 n1085 n1084 n1083 NAND3XLTS
XU166 n2134 n1808 n1807 n1806 NAND3XLTS
XU167 n2133 n1799 n1798 n1797 NAND3XLTS
XU168 n2132 n1793 n1792 n1791 NAND3XLTS
XU169 n2131 n1785 n1784 n1783 NAND3XLTS
XU170 n2006 n979 n978 n977 NAND3XLTS
XU171 n2005 n973 n972 n971 NAND3XLTS
XU172 n2004 n965 n964 n963 NAND3XLTS
XU173 n2003 n956 n955 n954 NAND3XLTS
XU174 n2048 n1434 n1433 n1432 NAND3XLTS
XU175 n2047 n1428 n1427 n1426 NAND3XLTS
XU176 n2046 n1424 n1423 n1422 NAND3XLTS
XU177 n2045 n1420 n1419 n1418 NAND3XLTS
XU178 n2044 n1411 n1410 n1409 NAND3XLTS
XU179 n2043 n1406 n1405 n1404 NAND3XLTS
XU180 n2054 n1460 n1459 n1458 NAND3XLTS
XU181 n2053 n1455 n1454 n1453 NAND3XLTS
XU182 n2052 n1452 n1451 n1450 NAND3XLTS
XU183 n2051 n1448 n1447 n1446 NAND3XLTS
XU184 n2050 n1443 n1442 n1441 NAND3XLTS
XU185 n2049 n1438 n1437 n1436 NAND3XLTS
XU186 n2098 n1716 n1715 n1714 NAND3XLTS
XU187 n2097 n1708 n1707 n1706 NAND3XLTS
XU188 n2096 n1701 n1700 n1699 NAND3XLTS
XU189 n2095 n1693 n1692 n1691 NAND3XLTS
XU190 n1994 n907 n906 n905 NAND3XLTS
XU191 n1993 n902 n901 n900 NAND3XLTS
XU192 n1992 n897 n896 n895 NAND3XLTS
XU193 n1991 n893 n892 n891 NAND3XLTS
XU194 n2086 n1688 n1687 n1686 NAND3XLTS
XU195 n2085 n1680 n1679 n1678 NAND3XLTS
XU196 n2084 n1673 n1672 n1671 NAND3XLTS
XU197 n2083 n1664 n1663 n1662 NAND3XLTS
XU198 n1990 n890 n889 n888 NAND3XLTS
XU199 n1989 n885 n884 n883 NAND3XLTS
XU200 n1988 n880 n879 n878 NAND3XLTS
XU201 n1987 n877 n876 n875 NAND3XLTS
XU202 n2170 n1917 n1916 n1915 NAND3XLTS
XU203 n2169 n1908 n1907 n1906 NAND3XLTS
XU204 n2168 n1896 n1895 n1894 NAND3XLTS
XU205 n2167 n1886 n1885 n1884 NAND3XLTS
XU206 n2018 n1054 n1053 n1052 NAND3XLTS
XU207 n2017 n1047 n1046 n1045 NAND3XLTS
XU208 n2016 n1042 n1041 n1040 NAND3XLTS
XU209 n2015 n1036 n1035 n1034 NAND3XLTS
XU210 n2158 n1878 n1877 n1876 NAND3XLTS
XU211 n2157 n1868 n1867 n1866 NAND3XLTS
XU212 n2156 n1855 n1854 n1853 NAND3XLTS
XU213 n2155 n1844 n1843 n1842 NAND3XLTS
XU214 n2014 n1029 n1028 n1027 NAND3XLTS
XU215 n2013 n1021 n1020 n1019 NAND3XLTS
XU216 n2012 n1013 n1012 n1011 NAND3XLTS
XU217 n2011 n1004 n1003 n1002 NAND3XLTS
XU218 n2036 n1373 n1372 n1371 NAND3XLTS
XU219 n2035 n1367 n1366 n1365 NAND3XLTS
XU220 n2034 n1363 n1362 n1361 NAND3XLTS
XU221 n2033 n1358 n1357 n1356 NAND3XLTS
XU222 n2032 n1351 n1350 n1349 NAND3XLTS
XU223 n2031 n1346 n1345 n1344 NAND3XLTS
XU224 n2042 n1401 n1400 n1399 NAND3XLTS
XU225 n2041 n1396 n1395 n1394 NAND3XLTS
XU226 n2040 n1390 n1389 n1388 NAND3XLTS
XU227 n2039 n1387 n1386 n1385 NAND3XLTS
XU228 n2038 n1382 n1381 n1380 NAND3XLTS
XU229 n2037 n1377 n1376 n1375 NAND3XLTS
XU230 n2122 n1779 n1778 n1777 NAND3XLTS
XU231 n2121 n1773 n1772 n1771 NAND3XLTS
XU232 n2120 n1763 n1762 n1761 NAND3XLTS
XU233 n2119 n1755 n1754 n1753 NAND3XLTS
XU234 n2002 n949 n948 n947 NAND3XLTS
XU235 n2001 n942 n941 n940 NAND3XLTS
XU236 n2000 n937 n936 n935 NAND3XLTS
XU237 n1999 n931 n930 n929 NAND3XLTS
XU238 n2110 n1750 n1749 n1748 NAND3XLTS
XU239 n2109 n1741 n1740 n1739 NAND3XLTS
XU240 n2108 n1730 n1729 n1728 NAND3XLTS
XU241 n2107 n1722 n1721 n1720 NAND3XLTS
XU242 n1998 n924 n923 n922 NAND3XLTS
XU243 n1997 n917 n916 n915 NAND3XLTS
XU244 n1996 n914 n913 n912 NAND3XLTS
XU245 n1995 n910 n909 n908 NAND3XLTS
XU246 n2060 n1513 n1512 n1511 NAND3XLTS
XU247 n2059 n1504 n1503 n1502 NAND3XLTS
XU248 n2058 n1497 n1496 n1495 NAND3XLTS
XU249 n2057 n1489 n1488 n1487 NAND3XLTS
XU250 n2056 n1477 n1476 n1475 NAND3XLTS
XU251 n2055 n1468 n1467 n1466 NAND3XLTS
XU252 n2066 n1563 n1562 n1561 NAND3XLTS
XU253 n2065 n1555 n1554 n1553 NAND3XLTS
XU254 n2064 n1547 n1546 n1545 NAND3XLTS
XU255 n2063 n1540 n1539 n1538 NAND3XLTS
XU256 n2062 n1532 n1531 n1530 NAND3XLTS
XU257 n2061 n1522 n1521 n1520 NAND3XLTS
XU258 n2024 n1080 n1079 n1078 NAND3XLTS
XU259 n2023 n1076 n1075 n1074 NAND3XLTS
XU260 n2022 n1072 n1071 n1070 NAND3XLTS
XU261 n2021 n1069 n1068 n1067 NAND3XLTS
XU262 n2020 n1063 n1062 n1061 NAND3XLTS
XU263 n2019 n1058 n1057 n1056 NAND3XLTS
XU264 n2146 n1836 n1835 n1834 NAND3XLTS
XU265 n2145 n1829 n1828 n1827 NAND3XLTS
XU266 n2144 n1820 n1819 n1818 NAND3XLTS
XU267 n2143 n1813 n1812 n1811 NAND3XLTS
XU268 n2010 n997 n996 n995 NAND3XLTS
XU269 n2009 n992 n991 n990 NAND3XLTS
XU270 n2008 n988 n987 n986 NAND3XLTS
XU271 n2007 n982 n981 n980 NAND3XLTS
XU272 n347 n311 n310 OR2X1TS
XU273 n29 n31 n26 NAND2X1TS
XU274 n1 n1646 n387 OR2X1TS
XU275 n2 n1590 n222 OR2X1TS
XU276 n3 n1621 n183 OR2X1TS
XU277 n4 n1634 n316 OR2X1TS
XU278 n5 n1648 n387 OR2X1TS
XU279 n6 n1623 n183 OR2X1TS
XU280 n7 n1636 n316 OR2X1TS
XU281 n8 n20 FE_DBTN108_n1946 n25 OA21XLTS
XU282 n9 n24 n506 OR2X1TS
XU283 n10 n1600 n274 OR2X1TS
XU284 n11 FE_DBTN101_n214 n1631 OR2X1TS
XU285 n12 n1601 n274 OR2X1TS
XU286 n419 n383 FE_DBTN112_n14 OR2X1TS
XU287 n128 n29 n131 NOR2XLTS
XU288 n35 n1572 n1567 n39 NOR3XLTS
XU289 n78 n1583 n1578 n84 NOR3XLTS
XU290 n268 n1608 n1602 n273 NOR3XLTS
XU291 n178 n1630 n1624 n182 NOR3XLTS
XU292 n308 n1643 n1637 n314 NOR3XLTS
XU293 n382 n1656 n1649 n386 NOR3XLTS
XU294 n13 FE_DBTN101_n214 n1597 OR2X1TS
XU295 n14 FE_DBTN101_n214 n1657 OR2X1TS
XU296 n690 n1934 n518 NOR2XLTS
XU297 n543 n1934 n517 NOR2XLTS
XU316 n18 n17 FE_DBTN87_n1942 n459 ADDHX1TS
XU317 n73 n17 INVX2TS
XU319 n454 selectBit_WEST INVX2TS
XU321 n1572 n1570 INVX2TS
XU323 n20 FE_DBTN91_n1938 n504 NOR2X1TS
XU325 n506 selectBit_SOUTH INVX2TS
XU326 n213 n9 INVX2TS
XU330 n25 n20 FE_DBTN108_n1946 NAND2X1TS
XU332 n23 selectBit_SOUTH n24 NAND2X1TS
XU333 n263 selectBit_SOUTH n24 n23 OAI21XLTS
XU334 n123 n305 n263 NAND2X1TS
XU336 n124 n25 INVX2TS
XU338 n26 FE_DBTN97_n1944 n25 n124 FE_DBTN88_n1943 AOI22X1TS
XU339 n27 n26 INVX2TS
XU341 n119 n29 INVX2TS
XU343 n264 selectBit_EAST n122 NAND2X1TS
XU344 n34 FE_DBTN97_n1944 n124 NAND2X1TS
XU347 n538 selectBit_NORTH selectBit_SOUTH NOR2XLTS
XU350 n523 n538 n507 NAND2X1TS
XU354 n37 n38 n34 n1565 FE_DBTN101_n214 AOI31XLTS
XU356 n39 n37 n1573 NAND2X1TS
XU357 n1525 n35 INVX2TS
XU360 n229 destinationAddressIn_EAST[8] INVX2TS
XU364 n50 n1570 n39 OR2X1TS
XU368 n42 FE_DBTN110_n1533 destinationAddressbuffer[7][8] FE_DBTN111_n50
+ destinationAddressIn_WEST[8] AOI22X1TS
XU372 n62 n1566 n40 OR2X1TS
XU376 n41 n43 destinationAddressIn_SOUTH[8] FE_DBTN109_n62
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU377 n2091 n1525 n229 n42 n41 OAI211XLTS
XU379 n234 destinationAddressIn_EAST[9] INVX2TS
XU383 n46 FE_DBTN110_n1533 destinationAddressbuffer[7][9] FE_DBTN111_n50
+ destinationAddressIn_WEST[9] AOI22X1TS
XU392 n45 n43 destinationAddressIn_SOUTH[9] FE_DBTN109_n62
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU393 n2092 n1525 n234 n46 n45 OAI211XLTS
XU395 n217 destinationAddressIn_EAST[10] INVX2TS
XU399 n49 FE_DBTN110_n1533 destinationAddressbuffer[7][10] FE_DBTN111_n50
+ destinationAddressIn_WEST[10] AOI22X1TS
XU405 n48 n43 destinationAddressIn_SOUTH[10] FE_DBTN109_n62
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU406 n2093 n1525 n217 n49 n48 OAI211XLTS
XU407 n225 destinationAddressIn_EAST[11] INVX2TS
XU413 n55 FE_DBTN110_n1533 destinationAddressbuffer[7][11] FE_DBTN111_n50
+ destinationAddressIn_WEST[11] AOI22X1TS
XU418 n54 n43 destinationAddressIn_SOUTH[11] FE_DBTN109_n62
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU419 n2094 n1525 n225 n55 n54 OAI211XLTS
XU420 n239 writeIn_EAST INVX2TS
XU424 n57 FE_DBTN110_n1533 writeOutbuffer[7] FE_DBTN111_n50 writeIn_WEST
+ AOI22X1TS
XU425 n153 writeIn_SOUTH INVX2TS
XU427 n56 n43 writeIn_SOUTH FE_DBTN109_n62 writeIn_NORTH AOI22X1TS
XU428 n2067 n1525 n239 n57 n56 OAI211XLTS
XU429 n252 destinationAddressIn_EAST[5] INVX2TS
XU431 n61 FE_DBTN110_n1533 destinationAddressbuffer[7][5] FE_DBTN111_n50
+ destinationAddressIn_WEST[5] AOI22X1TS
XU432 n157 destinationAddressIn_SOUTH[5] INVX2TS
XU434 n60 n43 destinationAddressIn_SOUTH[5] FE_DBTN109_n62
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU435 n2088 n1525 n252 n61 n60 OAI211XLTS
XU436 n246 destinationAddressIn_EAST[4] INVX2TS
XU437 n64 FE_DBTN110_n1533 destinationAddressbuffer[7][4] FE_DBTN111_n50
+ destinationAddressIn_WEST[4] AOI22X1TS
XU438 n174 destinationAddressIn_SOUTH[4] INVX2TS
XU441 n63 n43 destinationAddressIn_SOUTH[4] FE_DBTN109_n62
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU442 n2087 n1525 n246 n64 n63 OAI211XLTS
XU443 n258 destinationAddressIn_EAST[7] INVX2TS
XU444 n66 FE_DBTN110_n1533 destinationAddressbuffer[7][7] FE_DBTN111_n50
+ destinationAddressIn_WEST[7] AOI22X1TS
XU445 n168 destinationAddressIn_SOUTH[7] INVX2TS
XU447 n65 n43 destinationAddressIn_SOUTH[7] FE_DBTN109_n62
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU448 n2090 n1525 n258 n66 n65 OAI211XLTS
XU449 n243 destinationAddressIn_EAST[6] INVX2TS
XU450 n71 FE_DBTN110_n1533 destinationAddressbuffer[7][6] FE_DBTN111_n50
+ destinationAddressIn_WEST[6] AOI22X1TS
XU451 n163 destinationAddressIn_SOUTH[6] INVX2TS
XU453 n70 n43 destinationAddressIn_SOUTH[6] FE_DBTN109_n62
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU454 n2089 n1525 n243 n71 n70 OAI211XLTS
XU455 n176 n16 INVX2TS
XU456 n262 n121 selectBit_WEST NAND2X1TS
XU457 n375 n213 FE_DBTN117_n8 n305 AOI21X1TS
XU460 n378 FE_DBTN87_n1942 n504 NOR2XLTS
XU462 n1577 n26 n23 FE_DBTN117_n8 NOR3XLTS
XU463 n76 FE_DBTN97_n1944 FE_DBTN108_n1946 n378 n1577 AOI31XLTS
XU464 n81 n83 n76 FE_DBTN101_n214 AOI21X1TS
XU467 n84 n81 n1584 NAND2X1TS
XU468 n1462 n78 INVX2TS
XU476 n96 n1581 n84 OR2X1TS
XU480 n88 FE_DBTN106_n1479 destinationAddressbuffer[6][11] FE_DBTN107_n96
+ destinationAddressIn_WEST[11] AOI22X1TS
XU487 n87 n93 destinationAddressIn_NORTH[11] n86 destinationAddressIn_SOUTH[11]
+ AOI22X1TS
XU488 n2106 n1462 n225 n88 n87 OAI211XLTS
XU491 n91 FE_DBTN106_n1479 destinationAddressbuffer[6][10] FE_DBTN107_n96
+ destinationAddressIn_WEST[10] AOI22X1TS
XU497 n90 n93 destinationAddressIn_NORTH[10] n86 destinationAddressIn_SOUTH[10]
+ AOI22X1TS
XU498 n2105 n1462 n217 n91 n90 OAI211XLTS
XU500 n95 FE_DBTN106_n1479 destinationAddressbuffer[6][9] FE_DBTN107_n96
+ destinationAddressIn_WEST[9] AOI22X1TS
XU505 n94 n93 destinationAddressIn_NORTH[9] n86 destinationAddressIn_SOUTH[9]
+ AOI22X1TS
XU506 n2104 n1462 n234 n95 n94 OAI211XLTS
XU508 n99 FE_DBTN106_n1479 destinationAddressbuffer[6][8] FE_DBTN107_n96
+ destinationAddressIn_WEST[8] AOI22X1TS
XU512 n98 n93 destinationAddressIn_NORTH[8] n86 destinationAddressIn_SOUTH[8]
+ AOI22X1TS
XU513 n2103 n1462 n229 n99 n98 OAI211XLTS
XU515 n102 FE_DBTN106_n1479 writeOutbuffer[6] FE_DBTN107_n96 writeIn_WEST
+ AOI22X1TS
XU520 n101 n93 writeIn_NORTH n86 writeIn_SOUTH AOI22X1TS
XU521 n2068 n1462 n239 n102 n101 OAI211XLTS
XU523 n107 FE_DBTN106_n1479 destinationAddressbuffer[6][7] FE_DBTN107_n96
+ destinationAddressIn_WEST[7] AOI22X1TS
XU529 n106 n93 destinationAddressIn_NORTH[7] n86 destinationAddressIn_SOUTH[7]
+ AOI22X1TS
XU530 n2102 n1462 n258 n107 n106 OAI211XLTS
XU531 n109 FE_DBTN106_n1479 destinationAddressbuffer[6][6] FE_DBTN107_n96
+ destinationAddressIn_WEST[6] AOI22X1TS
XU535 n108 n93 destinationAddressIn_NORTH[6] n86 destinationAddressIn_SOUTH[6]
+ AOI22X1TS
XU536 n2101 n1462 n243 n109 n108 OAI211XLTS
XU537 n113 FE_DBTN106_n1479 destinationAddressbuffer[6][5] FE_DBTN107_n96
+ destinationAddressIn_WEST[5] AOI22X1TS
XU541 n112 n93 destinationAddressIn_NORTH[5] n86 destinationAddressIn_SOUTH[5]
+ AOI22X1TS
XU542 n2100 n1462 n252 n113 n112 OAI211XLTS
XU543 n118 FE_DBTN106_n1479 destinationAddressbuffer[6][4] FE_DBTN107_n96
+ destinationAddressIn_WEST[4] AOI22X1TS
XU547 n117 n93 destinationAddressIn_NORTH[4] n86 destinationAddressIn_SOUTH[4]
+ AOI22X1TS
XU548 n2099 n1462 n246 n118 n117 OAI211XLTS
XU549 n513 selectBit_EAST INVX2TS
XU552 n125 n124 FE_DBTN88_n1943 NAND2X1TS
XU554 n130 n127 n29 n125 FE_DBTN101_n214 AOI31XLTS
XU556 n968 n128 INVX2TS
XU563 n142 n1617 n1612 n132 NOR3XLTS
XU566 n136 FE_DBTN105_n1384 destinationAddressbuffer[3][11] n142
+ destinationAddressIn_EAST[11] AOI22X1TS
XU567 n159 n119 n131 OR2X1TS
XU574 n135 FE_DBTN104_n159 destinationAddressIn_NORTH[11] n133
+ destinationAddressIn_WEST[11] AOI22X1TS
XU575 n2142 n968 n137 n136 n135 OAI211XLTS
XU577 n139 FE_DBTN105_n1384 destinationAddressbuffer[3][10] n142
+ destinationAddressIn_EAST[10] AOI22X1TS
XU581 n138 FE_DBTN104_n159 destinationAddressIn_NORTH[10] n133
+ destinationAddressIn_WEST[10] AOI22X1TS
XU582 n2141 n968 n140 n139 n138 OAI211XLTS
XU586 n144 FE_DBTN105_n1384 destinationAddressbuffer[3][9] n142
+ destinationAddressIn_EAST[9] AOI22X1TS
XU590 n143 FE_DBTN104_n159 destinationAddressIn_NORTH[9] n133
+ destinationAddressIn_WEST[9] AOI22X1TS
XU591 n2140 n968 n145 n144 n143 OAI211XLTS
XU592 n148 FE_DBTN105_n1384 destinationAddressbuffer[3][8] n142
+ destinationAddressIn_EAST[8] AOI22X1TS
XU595 n147 FE_DBTN104_n159 destinationAddressIn_NORTH[8] n133
+ destinationAddressIn_WEST[8] AOI22X1TS
XU596 n2139 n968 n149 n148 n147 OAI211XLTS
XU599 n152 FE_DBTN105_n1384 writeOutbuffer[3] n142 writeIn_EAST AOI22X1TS
XU602 n151 FE_DBTN104_n159 writeIn_NORTH n133 writeIn_WEST AOI22X1TS
XU603 n2071 n968 n153 n152 n151 OAI211XLTS
XU605 n156 FE_DBTN105_n1384 destinationAddressbuffer[3][5] n142
+ destinationAddressIn_EAST[5] AOI22X1TS
XU608 n155 FE_DBTN104_n159 destinationAddressIn_NORTH[5] n133
+ destinationAddressIn_WEST[5] AOI22X1TS
XU609 n2136 n968 n157 n156 n155 OAI211XLTS
XU610 n162 FE_DBTN105_n1384 destinationAddressbuffer[3][6] n142
+ destinationAddressIn_EAST[6] AOI22X1TS
XU616 n161 FE_DBTN104_n159 destinationAddressIn_NORTH[6] n133
+ destinationAddressIn_WEST[6] AOI22X1TS
XU617 n2137 n968 n163 n162 n161 OAI211XLTS
XU618 n167 FE_DBTN105_n1384 destinationAddressbuffer[3][7] n142
+ destinationAddressIn_EAST[7] AOI22X1TS
XU621 n166 FE_DBTN104_n159 destinationAddressIn_NORTH[7] n133
+ destinationAddressIn_WEST[7] AOI22X1TS
XU622 n2138 n968 n168 n167 n166 OAI211XLTS
XU624 n173 FE_DBTN105_n1384 destinationAddressbuffer[3][4] n142
+ destinationAddressIn_EAST[4] AOI22X1TS
XU627 n172 FE_DBTN104_n159 destinationAddressIn_NORTH[4] n133
+ destinationAddressIn_WEST[4] AOI22X1TS
XU628 n2135 n968 n174 n173 n172 OAI211XLTS
XU629 n306 n263 INVX2TS
XU631 n1627 n375 n263 n374 NOR3XLTS
XU632 n177 FE_DBTN108_n1946 n378 FE_DBTN88_n1943 n1623 AOI31XLTS
XU633 n179 n181 n177 FE_DBTN101_n214 AOI21X1TS
XU634 n182 n179 n1631 NAND2X1TS
XU635 n1353 n178 INVX2TS
XU641 n191 n1628 n182 OR2X1TS
XU645 n185 FE_DBTN102_n1352 destinationAddressbuffer[2][11] FE_DBTN103_n191
+ destinationAddressIn_WEST[11] AOI22X1TS
XU647 n184 FE_DBTN119_n6 destinationAddressIn_NORTH[11] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU648 n2154 n1353 n225 n185 n184 OAI211XLTS
XU651 n187 FE_DBTN102_n1352 destinationAddressbuffer[2][9] FE_DBTN103_n191
+ destinationAddressIn_WEST[9] AOI22X1TS
XU655 n186 FE_DBTN119_n6 destinationAddressIn_NORTH[9] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU656 n2152 n1353 n234 n187 n186 OAI211XLTS
XU658 n190 FE_DBTN102_n1352 destinationAddressbuffer[2][8] FE_DBTN103_n191
+ destinationAddressIn_WEST[8] AOI22X1TS
XU660 n189 FE_DBTN119_n6 destinationAddressIn_NORTH[8] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU661 n2151 n1353 n229 n190 n189 OAI211XLTS
XU663 n195 FE_DBTN102_n1352 destinationAddressbuffer[2][10] FE_DBTN103_n191
+ destinationAddressIn_WEST[10] AOI22X1TS
XU666 n194 FE_DBTN119_n6 destinationAddressIn_NORTH[10] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU667 n2153 n1353 n217 n195 n194 OAI211XLTS
XU669 n197 FE_DBTN102_n1352 writeOutbuffer[2] FE_DBTN103_n191 writeIn_WEST
+ AOI22X1TS
XU671 n196 FE_DBTN119_n6 writeIn_NORTH FE_DBTN122_n3 writeIn_SOUTH AOI22X1TS
XU672 n2072 n1353 n239 n197 n196 OAI211XLTS
XU674 n200 FE_DBTN102_n1352 destinationAddressbuffer[2][7] FE_DBTN103_n191
+ destinationAddressIn_WEST[7] AOI22X1TS
XU678 n199 FE_DBTN119_n6 destinationAddressIn_NORTH[7] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU679 n2150 n1353 n258 n200 n199 OAI211XLTS
XU680 n203 FE_DBTN102_n1352 destinationAddressbuffer[2][4] FE_DBTN103_n191
+ destinationAddressIn_WEST[4] AOI22X1TS
XU681 n202 FE_DBTN119_n6 destinationAddressIn_NORTH[4] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU682 n2147 n1353 n246 n203 n202 OAI211XLTS
XU683 n206 FE_DBTN102_n1352 destinationAddressbuffer[2][6] FE_DBTN103_n191
+ destinationAddressIn_WEST[6] AOI22X1TS
XU684 n205 FE_DBTN119_n6 destinationAddressIn_NORTH[6] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU685 n2149 n1353 n243 n206 n205 OAI211XLTS
XU686 n211 FE_DBTN102_n1352 destinationAddressbuffer[2][5] FE_DBTN103_n191
+ destinationAddressIn_WEST[5] AOI22X1TS
XU687 n210 FE_DBTN119_n6 destinationAddressIn_NORTH[5] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU688 n2148 n1353 n252 n211 n210 OAI211XLTS
XU691 n218 n219 n1587 n215 FE_DBTN101_n214 AOI31XLTS
XU693 n220 n218 n1597 NAND2X1TS
XU694 n1435 n216 INVX2TS
XU701 n235 n1594 n220 OR2X1TS
XU703 n224 FE_DBTN98_n1444 destinationAddressbuffer[5][10] FE_DBTN100_n235
+ destinationAddressIn_WEST[10] AOI22X1TS
XU707 n253 n1587 n222 OR2X1TS
XU708 n223 FE_DBTN123_n2 destinationAddressIn_NORTH[10] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU709 n2117 n1435 n217 n224 n223 OAI211XLTS
XU713 n227 FE_DBTN98_n1444 destinationAddressbuffer[5][11] FE_DBTN100_n235
+ destinationAddressIn_WEST[11] AOI22X1TS
XU715 n226 FE_DBTN123_n2 destinationAddressIn_NORTH[11] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU716 n2118 n1435 n225 n227 n226 OAI211XLTS
XU721 n233 FE_DBTN98_n1444 destinationAddressbuffer[5][8] FE_DBTN100_n235
+ destinationAddressIn_WEST[8] AOI22X1TS
XU724 n232 FE_DBTN123_n2 destinationAddressIn_NORTH[8] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU725 n2115 n1435 n229 n233 n232 OAI211XLTS
XU728 n238 FE_DBTN98_n1444 destinationAddressbuffer[5][9] FE_DBTN100_n235
+ destinationAddressIn_WEST[9] AOI22X1TS
XU732 n237 FE_DBTN123_n2 destinationAddressIn_NORTH[9] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU733 n2116 n1435 n234 n238 n237 OAI211XLTS
XU736 n242 FE_DBTN98_n1444 writeOutbuffer[5] FE_DBTN100_n235 writeIn_WEST
+ AOI22X1TS
XU738 n241 FE_DBTN123_n2 writeIn_NORTH FE_DBTN99_n253 writeIn_SOUTH AOI22X1TS
XU739 n2069 n1435 n239 n242 n241 OAI211XLTS
XU742 n245 FE_DBTN98_n1444 destinationAddressbuffer[5][6] FE_DBTN100_n235
+ destinationAddressIn_WEST[6] AOI22X1TS
XU743 n244 FE_DBTN123_n2 destinationAddressIn_NORTH[6] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU744 n2113 n1435 n243 n245 n244 OAI211XLTS
XU746 n250 FE_DBTN98_n1444 destinationAddressbuffer[5][4] FE_DBTN100_n235
+ destinationAddressIn_WEST[4] AOI22X1TS
XU748 n249 FE_DBTN123_n2 destinationAddressIn_NORTH[4] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU749 n2111 n1435 n246 n250 n249 OAI211XLTS
XU751 n256 FE_DBTN98_n1444 destinationAddressbuffer[5][5] FE_DBTN100_n235
+ destinationAddressIn_WEST[5] AOI22X1TS
XU752 n255 FE_DBTN123_n2 destinationAddressIn_NORTH[5] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU753 n2112 n1435 n252 n256 n255 OAI211XLTS
XU755 n261 FE_DBTN98_n1444 destinationAddressbuffer[5][7] FE_DBTN100_n235
+ destinationAddressIn_WEST[7] AOI22X1TS
XU757 n260 FE_DBTN123_n2 destinationAddressIn_NORTH[7] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU758 n2114 n1435 n258 n261 n260 OAI211XLTS
XU759 n266 FE_DBTN97_n1944 n378 FE_DBTN92_n1941 n1601 AOI31XLTS
XU760 n271 n272 n266 FE_DBTN101_n214 AOI21X1TS
XU761 n273 n271 n1609 NAND2X1TS
XU762 n1402 n268 INVX2TS
XU769 n285 n1605 n273 OR2X1TS
XU771 n277 FE_DBTN95_n1413 destinationAddressbuffer[4][10] FE_DBTN96_n285
+ destinationAddressIn_WEST[10] AOI22X1TS
XU775 n276 FE_DBTN116_n10 destinationAddressIn_SOUTH[10] FE_DBTN114_n12
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU776 n2129 n1402 n217 n277 n276 OAI211XLTS
XU779 n280 FE_DBTN95_n1413 destinationAddressbuffer[4][11] FE_DBTN96_n285
+ destinationAddressIn_WEST[11] AOI22X1TS
XU782 n279 FE_DBTN116_n10 destinationAddressIn_SOUTH[11] FE_DBTN114_n12
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU783 n2130 n1402 n225 n280 n279 OAI211XLTS
XU787 n284 FE_DBTN95_n1413 destinationAddressbuffer[4][8] FE_DBTN96_n285
+ destinationAddressIn_WEST[8] AOI22X1TS
XU790 n283 FE_DBTN116_n10 destinationAddressIn_SOUTH[8] FE_DBTN114_n12
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU791 n2127 n1402 n229 n284 n283 OAI211XLTS
XU793 n289 FE_DBTN95_n1413 destinationAddressbuffer[4][9] FE_DBTN96_n285
+ destinationAddressIn_WEST[9] AOI22X1TS
XU798 n288 FE_DBTN116_n10 destinationAddressIn_SOUTH[9] FE_DBTN114_n12
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU799 n2128 n1402 n234 n289 n288 OAI211XLTS
XU801 n291 FE_DBTN95_n1413 writeOutbuffer[4] FE_DBTN96_n285 writeIn_WEST
+ AOI22X1TS
XU803 n290 FE_DBTN116_n10 writeIn_SOUTH FE_DBTN114_n12 writeIn_NORTH AOI22X1TS
XU804 n2070 n1402 n239 n291 n290 OAI211XLTS
XU806 n293 FE_DBTN95_n1413 destinationAddressbuffer[4][7] FE_DBTN96_n285
+ destinationAddressIn_WEST[7] AOI22X1TS
XU807 n292 FE_DBTN116_n10 destinationAddressIn_SOUTH[7] FE_DBTN114_n12
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU808 n2126 n1402 n258 n293 n292 OAI211XLTS
XU809 n296 FE_DBTN95_n1413 destinationAddressbuffer[4][4] FE_DBTN96_n285
+ destinationAddressIn_WEST[4] AOI22X1TS
XU810 n295 FE_DBTN116_n10 destinationAddressIn_SOUTH[4] FE_DBTN114_n12
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU811 n2123 n1402 n246 n296 n295 OAI211XLTS
XU812 n300 FE_DBTN95_n1413 destinationAddressbuffer[4][5] FE_DBTN96_n285
+ destinationAddressIn_WEST[5] AOI22X1TS
XU814 n299 FE_DBTN116_n10 destinationAddressIn_SOUTH[5] FE_DBTN114_n12
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU815 n2124 n1402 n252 n300 n299 OAI211XLTS
XU816 n304 FE_DBTN95_n1413 destinationAddressbuffer[4][6] FE_DBTN96_n285
+ destinationAddressIn_WEST[6] AOI22X1TS
XU818 n303 FE_DBTN116_n10 destinationAddressIn_SOUTH[6] FE_DBTN114_n12
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU819 n2125 n1402 n243 n304 n303 OAI211XLTS
XU820 n307 n20 FE_DBTN92_n1941 FE_DBTN88_n1943 n1636 AOI31XLTS
XU821 n311 n313 n307 FE_DBTN101_n214 AOI21X1TS
XU822 n314 n311 n1644 NAND2X1TS
XU830 n334 n1640 n314 OR2X1TS
XU832 n320 FE_DBTN93_n347 destinationAddressbuffer[1][10] FE_DBTN94_n334
+ destinationAddressIn_WEST[10] AOI22X1TS
XU838 n319 FE_DBTN118_n7 destinationAddressIn_NORTH[10] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[10] AOI22X1TS
XU839 n2165 n1094 n217 n320 n319 OAI211XLTS
XU841 n325 FE_DBTN93_n347 destinationAddressbuffer[1][9] FE_DBTN94_n334
+ destinationAddressIn_WEST[9] AOI22X1TS
XU844 n324 FE_DBTN118_n7 destinationAddressIn_NORTH[9] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[9] AOI22X1TS
XU845 n2164 n1094 n234 n325 n324 OAI211XLTS
XU848 n333 FE_DBTN93_n347 destinationAddressbuffer[1][11] FE_DBTN94_n334
+ destinationAddressIn_WEST[11] AOI22X1TS
XU850 n332 FE_DBTN118_n7 destinationAddressIn_NORTH[11] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[11] AOI22X1TS
XU851 n2166 n1094 n225 n333 n332 OAI211XLTS
XU855 n341 FE_DBTN93_n347 destinationAddressbuffer[1][8] FE_DBTN94_n334
+ destinationAddressIn_WEST[8] AOI22X1TS
XU857 n340 FE_DBTN118_n7 destinationAddressIn_NORTH[8] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[8] AOI22X1TS
XU858 n2163 n1094 n229 n341 n340 OAI211XLTS
XU860 n346 FE_DBTN93_n347 writeOutbuffer[1] FE_DBTN94_n334 writeIn_WEST
+ AOI22X1TS
XU862 n345 FE_DBTN118_n7 writeIn_NORTH FE_DBTN121_n4 writeIn_SOUTH AOI22X1TS
XU863 n2073 n1094 n239 n346 n345 OAI211XLTS
XU865 n352 FE_DBTN93_n347 destinationAddressbuffer[1][5] FE_DBTN94_n334
+ destinationAddressIn_WEST[5] AOI22X1TS
XU867 n351 FE_DBTN118_n7 destinationAddressIn_NORTH[5] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[5] AOI22X1TS
XU868 n2160 n1094 n252 n352 n351 OAI211XLTS
XU869 n357 FE_DBTN93_n347 destinationAddressbuffer[1][7] FE_DBTN94_n334
+ destinationAddressIn_WEST[7] AOI22X1TS
XU870 n356 FE_DBTN118_n7 destinationAddressIn_NORTH[7] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[7] AOI22X1TS
XU871 n2162 n1094 n258 n357 n356 OAI211XLTS
XU872 n364 FE_DBTN93_n347 destinationAddressbuffer[1][4] FE_DBTN94_n334
+ destinationAddressIn_WEST[4] AOI22X1TS
XU873 n363 FE_DBTN118_n7 destinationAddressIn_NORTH[4] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[4] AOI22X1TS
XU874 n2159 n1094 n246 n364 n363 OAI211XLTS
XU875 n370 FE_DBTN93_n347 destinationAddressbuffer[1][6] FE_DBTN94_n334
+ destinationAddressIn_WEST[6] AOI22X1TS
XU877 n369 FE_DBTN118_n7 destinationAddressIn_NORTH[6] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[6] AOI22X1TS
XU878 n2161 n1094 n243 n370 n369 OAI211XLTS
XU879 n379 n378 FE_DBTN92_n1941 FE_DBTN88_n1943 n1648 AOI31XLTS
XU880 n383 n385 n379 FE_DBTN101_n214 AOI21X1TS
XU881 n386 n383 n1657 NAND2X1TS
XU882 n1065 n382 INVX2TS
XU888 n412 n1653 n386 OR2X1TS
XU890 n390 FE_DBTN90_n419 destinationAddressbuffer[0][8] FE_DBTN89_n412
+ destinationAddressIn_WEST[8] AOI22X1TS
XU893 n389 FE_DBTN124_n1 destinationAddressIn_SOUTH[8] FE_DBTN120_n5
+ destinationAddressIn_NORTH[8] AOI22X1TS
XU894 n2175 n1065 n229 n390 n389 OAI211XLTS
XU897 n396 FE_DBTN90_n419 destinationAddressbuffer[0][11] FE_DBTN89_n412
+ destinationAddressIn_WEST[11] AOI22X1TS
XU902 n395 FE_DBTN124_n1 destinationAddressIn_SOUTH[11] FE_DBTN120_n5
+ destinationAddressIn_NORTH[11] AOI22X1TS
XU903 n2178 n1065 n225 n396 n395 OAI211XLTS
XU905 n403 FE_DBTN90_n419 destinationAddressbuffer[0][10] FE_DBTN89_n412
+ destinationAddressIn_WEST[10] AOI22X1TS
XU906 n402 FE_DBTN124_n1 destinationAddressIn_SOUTH[10] FE_DBTN120_n5
+ destinationAddressIn_NORTH[10] AOI22X1TS
XU907 n2177 n1065 n217 n403 n402 OAI211XLTS
XU908 n410 FE_DBTN90_n419 destinationAddressbuffer[0][9] FE_DBTN89_n412
+ destinationAddressIn_WEST[9] AOI22X1TS
XU913 n409 FE_DBTN124_n1 destinationAddressIn_SOUTH[9] FE_DBTN120_n5
+ destinationAddressIn_NORTH[9] AOI22X1TS
XU914 n2176 n1065 n234 n410 n409 OAI211XLTS
XU919 n417 FE_DBTN90_n419 writeOutbuffer[0] FE_DBTN89_n412 writeIn_WEST
+ AOI22X1TS
XU921 n416 FE_DBTN124_n1 writeIn_SOUTH FE_DBTN120_n5 writeIn_NORTH AOI22X1TS
XU922 n2074 n1065 n239 n417 n416 OAI211XLTS
XU925 n422 FE_DBTN90_n419 destinationAddressbuffer[0][7] FE_DBTN89_n412
+ destinationAddressIn_WEST[7] AOI22X1TS
XU926 n421 FE_DBTN124_n1 destinationAddressIn_SOUTH[7] FE_DBTN120_n5
+ destinationAddressIn_NORTH[7] AOI22X1TS
XU927 n2174 n1065 n258 n422 n421 OAI211XLTS
XU928 n426 FE_DBTN90_n419 destinationAddressbuffer[0][4] FE_DBTN89_n412
+ destinationAddressIn_WEST[4] AOI22X1TS
XU929 n425 FE_DBTN124_n1 destinationAddressIn_SOUTH[4] FE_DBTN120_n5
+ destinationAddressIn_NORTH[4] AOI22X1TS
XU930 n2171 n1065 n246 n426 n425 OAI211XLTS
XU931 n433 FE_DBTN90_n419 destinationAddressbuffer[0][5] FE_DBTN89_n412
+ destinationAddressIn_WEST[5] AOI22X1TS
XU932 n432 FE_DBTN124_n1 destinationAddressIn_SOUTH[5] FE_DBTN120_n5
+ destinationAddressIn_NORTH[5] AOI22X1TS
XU933 n2172 n1065 n252 n433 n432 OAI211XLTS
XU934 n439 FE_DBTN90_n419 destinationAddressbuffer[0][6] FE_DBTN89_n412
+ destinationAddressIn_WEST[6] AOI22X1TS
XU936 n438 FE_DBTN124_n1 destinationAddressIn_SOUTH[6] FE_DBTN120_n5
+ destinationAddressIn_NORTH[6] AOI22X1TS
XU937 n2173 n1065 n243 n439 n438 OAI211XLTS
XU940 n530 n1939 INVX2TS
XU941 n528 FE_DBTN85_n1945 n530 NAND2X1TS
XU942 n502 FE_DBTN85_n1945 n1940 n528 OAI21XLTS
XU945 n837 n528 FE_DBTN83_n1936 NOR2XLTS
XU948 n499 n528 FE_DBTN83_n1936 n837 AOI21X1TS
XU949 n443 FE_DBTN108_n1946 n502 FE_DBTN88_n1943 n499 OAI22X1TS
XU950 n448 n502 FE_DBTN108_n1946 FE_DBTN88_n1943 n499 n443 AOI221XLTS
XU951 n445 n1933 INVX2TS
XU952 n461 FE_DBTN87_n1942 n445 NAND2X1TS
XU953 n465 FE_DBTN87_n1942 n1945 n461 OAI21XLTS
XU954 n449 n448 n465 n1935 AOI21X1TS
XU955 n492 reset INVX2TS
XU956 n503 n492 n1935 NAND2X1TS
XU957 n497 reset FE_DBTN101_n214 NOR2XLTS
XU961 n455 FE_DBTN97_n1944 FE_DBTN83_n1936 FE_DBTN84_n1937 FE_DBTN88_n1943
+ AOI22X1TS
XU963 n472 n475 INVX2TS
XU964 n471 FE_DBTN85_n1945 FE_DBTN91_n1938 n457 AOI21X1TS
XU965 n475 n477 n464 n463 ADDHXLTS
XU966 n466 n477 INVX2TS
XU967 n469 n467 n466 n465 AOI21X1TS
XU968 n468 n467 n466 n473 n472 OAI22X1TS
XU969 n470 n476 n469 n468 AOI21X1TS
XU970 n474 n473 n472 n471 n470 AOI211X1TS
XU971 n478 n474 INVX2TS
XU972 n482 n478 n475 NAND2X1TS
XU973 n481 FE_DBTN97_n1944 n479 XNOR2X1TS
XU974 n496 n482 n481 XOR2X1TS
XU975 n490 n496 INVX2TS
XU977 n486 n493 FE_DBTN87_n1942 n483 ADDHXLTS
XU978 n487 n1940 n494 XNOR2X1TS
XU979 N2624 n497 n491 n1947 n503 OAI2BB2XLTS
XU980 n501 n492 n1934 NAND2X1TS
XU981 n1956 n1933 n503 n501 n445 AOI22X1TS
XU982 n500 n499 INVX2TS
XU983 n1961 FE_DBTN83_n1936 n503 n500 n501 OAI22X1TS
XU984 n1962 n1939 n503 n502 n501 OAI22X1TS
XU991 n520 n1934 INVX2TS
XU992 n508 n538 n520 NAND2X1TS
XU993 n611 readReady selectBit_EAST n454 n508 NOR4XLTS
XU997 n541 readIn_SOUTH n543 readIn_WEST n611 AOI22X1TS
XU1002 n644 selectBit_WEST readReady n513 n508 NOR4XLTS
XU1006 n540 readIn_NORTH n690 readIn_EAST n644 AOI22X1TS
XU1007 n516 selectBit_EAST readReady n454 NOR3XLTS
XU1008 n515 selectBit_WEST readReady n513 NOR3XLTS
XU1009 n519 n516 n537 n515 n538 OAI31X1TS
XU1010 n673 n520 n519 n518 n517 NAND4XLTS
XU1015 n718 FE_DBTN85_n1945 FE_DBTN84_n1937 n1939 NOR3XLTS
XU1018 n692 FE_DBTN85_n1945 n1940 FE_DBTN84_n1937 NOR3XLTS
XU1021 n535 readOutbuffer[2] n718 readOutbuffer[0] n692 AOI22X1TS
XU1022 n719 FE_DBTN85_n1945 n1939 FE_DBTN83_n1936 NOR3XLTS
XU1025 n693 FE_DBTN85_n1945 n530 FE_DBTN83_n1936 NOR3XLTS
XU1028 n534 readOutbuffer[6] n719 readOutbuffer[4] n693 AOI22X1TS
XU1029 n720 FE_DBTN84_n1937 n528 NOR2XLTS
XU1032 n694 n530 FE_DBTN84_n1937 n1945 NOR3XLTS
XU1035 n533 readOutbuffer[3] n720 readOutbuffer[1] n694 AOI22X1TS
XU1037 n860 n1940 n445 FE_DBTN83_n1936 NOR3XLTS
XU1040 n532 readOutbuffer[7] n837 readOutbuffer[5] n860 AOI22X1TS
XU1041 n536 n535 n534 n533 n532 NAND4XLTS
XU1042 n539 readOut n550 n1934 n536 AOI22X1TS
XU1044 n553 writeIn_EAST n644 writeIn_WEST n611 AOI22X1TS
XU1047 n552 writeIn_NORTH n690 writeIn_SOUTH n543 AOI22X1TS
XU1048 n548 writeOutbuffer[2] n718 writeOutbuffer[0] n692 AOI22X1TS
XU1049 n547 writeOutbuffer[6] n719 writeOutbuffer[4] n693 AOI22X1TS
XU1050 n546 writeOutbuffer[3] n720 writeOutbuffer[1] n694 AOI22X1TS
XU1051 n545 writeOutbuffer[7] n837 writeOutbuffer[5] n860 AOI22X1TS
XU1052 n549 n548 n547 n546 n545 NAND4XLTS
XU1053 n551 writeOut n550 n1934 n549 AOI22X1TS
XU1058 n562 requesterAddressIn_NORTH[0] n690 requesterAddressIn_EAST[0] n644
+ AOI22X1TS
XU1064 n561 requesterAddressIn_SOUTH[0] n543 requesterAddressIn_WEST[0] n611
+ AOI22X1TS
XU1067 n557 requesterAddressbuffer[2][0] n718 requesterAddressbuffer[0][0] n692
+ AOI22X1TS
XU1068 n556 requesterAddressbuffer[6][0] n719 requesterAddressbuffer[4][0] n693
+ AOI22X1TS
XU1069 n555 requesterAddressbuffer[3][0] n720 requesterAddressbuffer[1][0] n694
+ AOI22X1TS
XU1072 n554 requesterAddressbuffer[7][0] n837 requesterAddressbuffer[5][0] n860
+ AOI22X1TS
XU1073 n558 n557 n556 n555 n554 NAND4XLTS
XU1074 n560 requesterAddressOut[0] FE_DBTN86_n673 n1934 n558 AOI22X1TS
XU1078 n606 readRequesterAddress[0] FE_DBTN82_n559 NAND2X1TS
XU1082 n579 requesterAddressIn_NORTH[1] n690 requesterAddressIn_EAST[1] n644
+ AOI22X1TS
XU1088 n578 requesterAddressIn_SOUTH[1] n543 requesterAddressIn_WEST[1] n611
+ AOI22X1TS
XU1089 n575 requesterAddressbuffer[2][1] n718 requesterAddressbuffer[0][1] n692
+ AOI22X1TS
XU1090 n574 requesterAddressbuffer[6][1] n719 requesterAddressbuffer[4][1] n693
+ AOI22X1TS
XU1091 n573 requesterAddressbuffer[3][1] n720 requesterAddressbuffer[1][1] n694
+ AOI22X1TS
XU1092 n572 requesterAddressbuffer[7][1] n837 requesterAddressbuffer[5][1] n860
+ AOI22X1TS
XU1093 n576 n575 n574 n573 n572 NAND4XLTS
XU1094 n577 requesterAddressOut[1] FE_DBTN86_n673 n1934 n576 AOI22X1TS
XU1097 n621 readRequesterAddress[1] FE_DBTN82_n559 NAND2X1TS
XU1102 n587 requesterAddressIn_NORTH[2] n690 requesterAddressIn_EAST[2] n644
+ AOI22X1TS
XU1107 n586 requesterAddressIn_SOUTH[2] n543 requesterAddressIn_WEST[2] n611
+ AOI22X1TS
XU1110 n583 requesterAddressbuffer[2][2] n718 requesterAddressbuffer[0][2] n692
+ AOI22X1TS
XU1112 n582 requesterAddressbuffer[6][2] n719 requesterAddressbuffer[4][2] n693
+ AOI22X1TS
XU1114 n581 requesterAddressbuffer[3][2] n720 requesterAddressbuffer[1][2] n694
+ AOI22X1TS
XU1116 n580 requesterAddressbuffer[7][2] n837 requesterAddressbuffer[5][2] n860
+ AOI22X1TS
XU1117 n584 n583 n582 n581 n580 NAND4XLTS
XU1118 n585 requesterAddressOut[2] FE_DBTN86_n673 n1934 n584 AOI22X1TS
XU1121 n640 readRequesterAddress[2] FE_DBTN82_n559 NAND2X1TS
XU1125 n598 requesterAddressIn_NORTH[3] n690 requesterAddressIn_EAST[3] n644
+ AOI22X1TS
XU1130 n597 requesterAddressIn_SOUTH[3] n543 requesterAddressIn_WEST[3] n611
+ AOI22X1TS
XU1131 n592 requesterAddressbuffer[2][3] n718 requesterAddressbuffer[0][3] n692
+ AOI22X1TS
XU1132 n591 requesterAddressbuffer[6][3] n719 requesterAddressbuffer[4][3] n693
+ AOI22X1TS
XU1133 n590 requesterAddressbuffer[3][3] n720 requesterAddressbuffer[1][3] n694
+ AOI22X1TS
XU1135 n589 requesterAddressbuffer[7][3] n837 requesterAddressbuffer[5][3] n860
+ AOI22X1TS
XU1136 n593 n592 n591 n590 n589 NAND4XLTS
XU1137 n596 requesterAddressOut[3] FE_DBTN86_n673 n1934 n593 AOI22X1TS
XU1140 n652 readRequesterAddress[3] FE_DBTN82_n559 NAND2X1TS
XU1144 n609 destinationAddressIn_NORTH[0] n690 destinationAddressIn_EAST[0]
+ n644 AOI22X1TS
XU1147 n608 destinationAddressIn_SOUTH[0] n543 destinationAddressIn_WEST[0]
+ n611 AOI22X1TS
XU1149 n604 destinationAddressbuffer[2][0] n718 destinationAddressbuffer[0][0]
+ n692 AOI22X1TS
XU1150 n603 destinationAddressbuffer[6][0] n719 destinationAddressbuffer[4][0]
+ n693 AOI22X1TS
XU1151 n602 destinationAddressbuffer[3][0] n720 destinationAddressbuffer[1][0]
+ n694 AOI22X1TS
XU1152 n601 destinationAddressbuffer[7][0] n837 destinationAddressbuffer[5][0]
+ n860 AOI22X1TS
XU1153 n605 n604 n603 n602 n601 NAND4XLTS
XU1154 n607 destinationAddressOut[0] FE_DBTN86_n673 n1934 n605 AOI22X1TS
XU1158 n624 destinationAddressIn_NORTH[1] n690 destinationAddressIn_EAST[1]
+ n644 AOI22X1TS
XU1161 n623 destinationAddressIn_SOUTH[1] n543 destinationAddressIn_WEST[1]
+ n611 AOI22X1TS
XU1162 n619 destinationAddressbuffer[2][1] n718 destinationAddressbuffer[0][1]
+ n692 AOI22X1TS
XU1163 n618 destinationAddressbuffer[6][1] n719 destinationAddressbuffer[4][1]
+ n693 AOI22X1TS
XU1164 n617 destinationAddressbuffer[3][1] n720 destinationAddressbuffer[1][1]
+ n694 AOI22X1TS
XU1165 n616 destinationAddressbuffer[7][1] n837 destinationAddressbuffer[5][1]
+ n860 AOI22X1TS
XU1166 n620 n619 n618 n617 n616 NAND4XLTS
XU1167 n622 destinationAddressOut[1] FE_DBTN86_n673 n1934 n620 AOI22X1TS
XU1172 n643 destinationAddressIn_NORTH[2] n690 destinationAddressIn_EAST[2]
+ n644 AOI22X1TS
XU1177 n642 destinationAddressIn_SOUTH[2] n543 destinationAddressIn_WEST[2]
+ n611 AOI22X1TS
XU1181 n638 destinationAddressbuffer[2][2] n718 destinationAddressbuffer[0][2]
+ n692 AOI22X1TS
XU1184 n637 destinationAddressbuffer[6][2] n719 destinationAddressbuffer[4][2]
+ n693 AOI22X1TS
XU1187 n636 destinationAddressbuffer[3][2] n720 destinationAddressbuffer[1][2]
+ n694 AOI22X1TS
XU1189 n635 destinationAddressbuffer[7][2] n837 destinationAddressbuffer[5][2]
+ n860 AOI22X1TS
XU1190 n639 n638 n637 n636 n635 NAND4XLTS
XU1191 n641 destinationAddressOut[2] FE_DBTN86_n673 n1934 n639 AOI22X1TS
XU1195 n655 destinationAddressIn_NORTH[3] n690 destinationAddressIn_EAST[3]
+ n644 AOI22X1TS
XU1198 n654 destinationAddressIn_SOUTH[3] n543 destinationAddressIn_WEST[3]
+ n611 AOI22X1TS
XU1199 n649 destinationAddressbuffer[2][3] n718 destinationAddressbuffer[0][3]
+ n692 AOI22X1TS
XU1200 n648 destinationAddressbuffer[6][3] n719 destinationAddressbuffer[4][3]
+ n693 AOI22X1TS
XU1201 n647 destinationAddressbuffer[3][3] n720 destinationAddressbuffer[1][3]
+ n694 AOI22X1TS
XU1202 n646 destinationAddressbuffer[7][3] n837 destinationAddressbuffer[5][3]
+ n860 AOI22X1TS
XU1203 n650 n649 n648 n647 n646 NAND4XLTS
XU1204 n653 destinationAddressOut[3] FE_DBTN86_n673 n1934 n650 AOI22X1TS
XU1205 n666 destinationAddressIn_EAST[4] n644 destinationAddressIn_WEST[4] n611
+ AOI22X1TS
XU1206 n665 destinationAddressIn_NORTH[4] n690 destinationAddressIn_SOUTH[4]
+ n543 AOI22X1TS
XU1207 n767 n1935 INVX2TS
XU1209 n662 destinationAddressbuffer[2][4] n718 destinationAddressbuffer[0][4]
+ n692 AOI22X1TS
XU1210 n661 destinationAddressbuffer[6][4] n719 destinationAddressbuffer[4][4]
+ n693 AOI22X1TS
XU1211 n660 destinationAddressbuffer[3][4] n720 destinationAddressbuffer[1][4]
+ n694 AOI22X1TS
XU1213 n659 destinationAddressbuffer[7][4] n837 destinationAddressbuffer[5][4]
+ n860 AOI22X1TS
XU1214 n663 n662 n661 n660 n659 NAND4XLTS
XU1215 n664 destinationAddressOut[4] FE_DBTN86_n673 n767 n663 AOI22X1TS
XU1217 n688 destinationAddressIn_EAST[5] n644 destinationAddressIn_WEST[5] n611
+ AOI22X1TS
XU1219 n687 destinationAddressIn_NORTH[5] n690 destinationAddressIn_SOUTH[5]
+ n543 AOI22X1TS
XU1221 n684 destinationAddressbuffer[2][5] n718 destinationAddressbuffer[0][5]
+ n692 AOI22X1TS
XU1222 n683 destinationAddressbuffer[6][5] n719 destinationAddressbuffer[4][5]
+ n693 AOI22X1TS
XU1223 n682 destinationAddressbuffer[3][5] n720 destinationAddressbuffer[1][5]
+ n694 AOI22X1TS
XU1224 n681 destinationAddressbuffer[7][5] n837 destinationAddressbuffer[5][5]
+ n860 AOI22X1TS
XU1225 n685 n684 n683 n682 n681 NAND4XLTS
XU1226 n686 destinationAddressOut[5] FE_DBTN86_n673 n767 n685 AOI22X1TS
XU1228 n703 destinationAddressIn_EAST[6] n644 destinationAddressIn_WEST[6] n611
+ AOI22X1TS
XU1230 n702 destinationAddressIn_NORTH[6] n690 destinationAddressIn_SOUTH[6]
+ n543 AOI22X1TS
XU1233 n698 destinationAddressbuffer[2][6] n718 destinationAddressbuffer[0][6]
+ n692 AOI22X1TS
XU1236 n697 destinationAddressbuffer[6][6] n719 destinationAddressbuffer[4][6]
+ n693 AOI22X1TS
XU1239 n696 destinationAddressbuffer[3][6] n720 destinationAddressbuffer[1][6]
+ n694 AOI22X1TS
XU1242 n695 destinationAddressbuffer[7][6] n837 destinationAddressbuffer[5][6]
+ n860 AOI22X1TS
XU1243 n699 n698 n697 n696 n695 NAND4XLTS
XU1244 n701 destinationAddressOut[6] FE_DBTN86_n673 n767 n699 AOI22X1TS
XU1245 n714 destinationAddressIn_EAST[7] n644 destinationAddressIn_WEST[7] n611
+ AOI22X1TS
XU1246 n713 destinationAddressIn_NORTH[7] n690 destinationAddressIn_SOUTH[7]
+ n543 AOI22X1TS
XU1248 n710 destinationAddressbuffer[2][7] n718 destinationAddressbuffer[0][7]
+ n692 AOI22X1TS
XU1249 n709 destinationAddressbuffer[6][7] n719 destinationAddressbuffer[4][7]
+ n693 AOI22X1TS
XU1250 n708 destinationAddressbuffer[3][7] n720 destinationAddressbuffer[1][7]
+ n694 AOI22X1TS
XU1251 n707 destinationAddressbuffer[7][7] n837 destinationAddressbuffer[5][7]
+ n860 AOI22X1TS
XU1252 n711 n710 n709 n708 n707 NAND4XLTS
XU1253 n712 destinationAddressOut[7] FE_DBTN86_n673 n767 n711 AOI22X1TS
XU1254 n728 destinationAddressIn_EAST[8] n644 destinationAddressIn_WEST[8] n611
+ AOI22X1TS
XU1255 n727 destinationAddressIn_NORTH[8] n690 destinationAddressIn_SOUTH[8]
+ n543 AOI22X1TS
XU1257 n724 destinationAddressbuffer[2][8] n718 destinationAddressbuffer[0][8]
+ n692 AOI22X1TS
XU1259 n723 destinationAddressbuffer[6][8] n719 destinationAddressbuffer[4][8]
+ n693 AOI22X1TS
XU1261 n722 destinationAddressbuffer[3][8] n720 destinationAddressbuffer[1][8]
+ n694 AOI22X1TS
XU1262 n721 destinationAddressbuffer[7][8] n837 destinationAddressbuffer[5][8]
+ n860 AOI22X1TS
XU1263 n725 n724 n723 n722 n721 NAND4XLTS
XU1264 n726 destinationAddressOut[8] FE_DBTN86_n673 n767 n725 AOI22X1TS
XU1265 n746 destinationAddressIn_EAST[9] n644 destinationAddressIn_WEST[9] n611
+ AOI22X1TS
XU1266 n745 destinationAddressIn_NORTH[9] n690 destinationAddressIn_SOUTH[9]
+ n543 AOI22X1TS
XU1267 n741 destinationAddressbuffer[2][9] n718 destinationAddressbuffer[0][9]
+ n692 AOI22X1TS
XU1268 n740 destinationAddressbuffer[6][9] n719 destinationAddressbuffer[4][9]
+ n693 AOI22X1TS
XU1269 n739 destinationAddressbuffer[3][9] n720 destinationAddressbuffer[1][9]
+ n694 AOI22X1TS
XU1270 n738 destinationAddressbuffer[7][9] n837 destinationAddressbuffer[5][9]
+ n860 AOI22X1TS
XU1271 n742 n741 n740 n739 n738 NAND4XLTS
XU1272 n744 destinationAddressOut[9] FE_DBTN86_n673 n767 n742 AOI22X1TS
XU1274 n761 destinationAddressIn_EAST[10] n644 destinationAddressIn_WEST[10]
+ n611 AOI22X1TS
XU1276 n760 destinationAddressIn_NORTH[10] n690 destinationAddressIn_SOUTH[10]
+ n543 AOI22X1TS
XU1279 n756 destinationAddressbuffer[2][10] n718
+ destinationAddressbuffer[0][10] n692 AOI22X1TS
XU1282 n755 destinationAddressbuffer[6][10] n719
+ destinationAddressbuffer[4][10] n693 AOI22X1TS
XU1285 n754 destinationAddressbuffer[3][10] n720
+ destinationAddressbuffer[1][10] n694 AOI22X1TS
XU1287 n753 destinationAddressbuffer[7][10] n837
+ destinationAddressbuffer[5][10] n860 AOI22X1TS
XU1288 n757 n756 n755 n754 n753 NAND4XLTS
XU1289 n759 destinationAddressOut[10] FE_DBTN86_n673 n767 n757 AOI22X1TS
XU1290 n775 destinationAddressIn_EAST[11] n644 destinationAddressIn_WEST[11]
+ n611 AOI22X1TS
XU1291 n774 destinationAddressIn_NORTH[11] n690 destinationAddressIn_SOUTH[11]
+ n543 AOI22X1TS
XU1293 n771 destinationAddressbuffer[2][11] n718
+ destinationAddressbuffer[0][11] n692 AOI22X1TS
XU1294 n770 destinationAddressbuffer[6][11] n719
+ destinationAddressbuffer[4][11] n693 AOI22X1TS
XU1295 n769 destinationAddressbuffer[3][11] n720
+ destinationAddressbuffer[1][11] n694 AOI22X1TS
XU1296 n768 destinationAddressbuffer[7][11] n837
+ destinationAddressbuffer[5][11] n860 AOI22X1TS
XU1297 n772 n771 n770 n769 n768 NAND4XLTS
XU1298 n773 destinationAddressOut[11] FE_DBTN86_n673 n767 n772 AOI22X1TS
XU1303 n785 dataIn_NORTH[0] n690 dataIn_EAST[0] n644 AOI22X1TS
XU1306 n784 dataIn_SOUTH[0] n543 dataIn_WEST[0] n611 AOI22X1TS
XU1307 n780 dataoutbuffer[0][0] n692 dataoutbuffer[2][0] n718 AOI22X1TS
XU1308 n779 dataoutbuffer[4][0] n693 dataoutbuffer[6][0] n719 AOI22X1TS
XU1309 n778 dataoutbuffer[1][0] n694 dataoutbuffer[3][0] n720 AOI22X1TS
XU1310 n777 dataoutbuffer[5][0] n860 dataoutbuffer[7][0] n837 AOI22X1TS
XU1311 n781 n780 n779 n778 n777 NAND4XLTS
XU1312 n783 dataOut[0] FE_DBTN86_n673 n767 n781 AOI22X1TS
XU1315 n782 cacheDataOut[0] FE_DBTN82_n559 NAND2X1TS
XU1319 n805 dataIn_NORTH[1] n690 dataIn_EAST[1] n644 AOI22X1TS
XU1322 n804 dataIn_SOUTH[1] n543 dataIn_WEST[1] n611 AOI22X1TS
XU1323 n800 dataoutbuffer[0][1] n692 dataoutbuffer[2][1] n718 AOI22X1TS
XU1324 n799 dataoutbuffer[4][1] n693 dataoutbuffer[6][1] n719 AOI22X1TS
XU1325 n798 dataoutbuffer[1][1] n694 dataoutbuffer[3][1] n720 AOI22X1TS
XU1326 n797 dataoutbuffer[5][1] n860 dataoutbuffer[7][1] n837 AOI22X1TS
XU1327 n801 n800 n799 n798 n797 NAND4XLTS
XU1328 n803 dataOut[1] FE_DBTN86_n673 n767 n801 AOI22X1TS
XU1331 n802 cacheDataOut[1] FE_DBTN82_n559 NAND2X1TS
XU1336 n824 dataIn_NORTH[2] n690 dataIn_EAST[2] n644 AOI22X1TS
XU1340 n823 dataIn_SOUTH[2] n543 dataIn_WEST[2] n611 AOI22X1TS
XU1343 n818 dataoutbuffer[0][2] n692 dataoutbuffer[2][2] n718 AOI22X1TS
XU1346 n817 dataoutbuffer[4][2] n693 dataoutbuffer[6][2] n719 AOI22X1TS
XU1349 n816 dataoutbuffer[1][2] n694 dataoutbuffer[3][2] n720 AOI22X1TS
XU1350 n815 dataoutbuffer[5][2] n860 dataoutbuffer[7][2] n837 AOI22X1TS
XU1351 n819 n818 n817 n816 n815 NAND4XLTS
XU1352 n822 dataOut[2] FE_DBTN86_n673 n767 n819 AOI22X1TS
XU1354 n821 cacheDataOut[2] FE_DBTN82_n559 NAND2X1TS
XU1358 n836 dataIn_NORTH[3] n690 dataIn_EAST[3] n644 AOI22X1TS
XU1361 n835 dataIn_SOUTH[3] n543 dataIn_WEST[3] n611 AOI22X1TS
XU1362 n830 dataoutbuffer[0][3] n692 dataoutbuffer[2][3] n718 AOI22X1TS
XU1363 n829 dataoutbuffer[4][3] n693 dataoutbuffer[6][3] n719 AOI22X1TS
XU1364 n828 dataoutbuffer[1][3] n694 dataoutbuffer[3][3] n720 AOI22X1TS
XU1365 n827 dataoutbuffer[5][3] n860 dataoutbuffer[7][3] n837 AOI22X1TS
XU1366 n831 n830 n829 n828 n827 NAND4XLTS
XU1367 n834 dataOut[3] FE_DBTN86_n673 n1934 n831 AOI22X1TS
XU1369 n833 cacheDataOut[3] FE_DBTN82_n559 NAND2X1TS
XU1373 n848 dataIn_NORTH[4] n690 dataIn_EAST[4] n644 AOI22X1TS
XU1376 n847 dataIn_SOUTH[4] n543 dataIn_WEST[4] n611 AOI22X1TS
XU1377 n841 dataoutbuffer[0][4] n692 dataoutbuffer[2][4] n718 AOI22X1TS
XU1378 n840 dataoutbuffer[4][4] n693 dataoutbuffer[6][4] n719 AOI22X1TS
XU1379 n839 dataoutbuffer[1][4] n694 dataoutbuffer[3][4] n720 AOI22X1TS
XU1380 n838 dataoutbuffer[5][4] n860 dataoutbuffer[7][4] n837 AOI22X1TS
XU1381 n842 n841 n840 n839 n838 NAND4XLTS
XU1382 n846 dataOut[4] FE_DBTN86_n673 n1934 n842 AOI22X1TS
XU1384 n845 cacheDataOut[4] FE_DBTN82_n559 NAND2X1TS
XU1388 n872 dataIn_NORTH[5] n690 dataIn_EAST[5] n644 AOI22X1TS
XU1391 n871 dataIn_SOUTH[5] n543 dataIn_WEST[5] n611 AOI22X1TS
XU1392 n864 dataoutbuffer[0][5] n692 dataoutbuffer[2][5] n718 AOI22X1TS
XU1393 n863 dataoutbuffer[4][5] n693 dataoutbuffer[6][5] n719 AOI22X1TS
XU1394 n862 dataoutbuffer[1][5] n694 dataoutbuffer[3][5] n720 AOI22X1TS
XU1395 n861 dataoutbuffer[5][5] n860 dataoutbuffer[7][5] n837 AOI22X1TS
XU1396 n865 n864 n863 n862 n861 NAND4XLTS
XU1397 n870 dataOut[5] FE_DBTN86_n673 n767 n865 AOI22X1TS
XU1399 n869 cacheDataOut[5] FE_DBTN82_n559 NAND2X1TS
XU1402 n877 readRequesterAddress[0] n36 FE_DBTN110_n1533
+ requesterAddressbuffer[7][0] AOI22X1TS
XU1405 n876 FE_DBTN111_n50 requesterAddressIn_WEST[0] n35
+ requesterAddressIn_EAST[0] AOI22X1TS
XU1409 n875 n43 requesterAddressIn_SOUTH[0] FE_DBTN109_n62
+ requesterAddressIn_NORTH[0] AOI22X1TS
XU1411 n880 n36 readRequesterAddress[1] FE_DBTN110_n1533
+ requesterAddressbuffer[7][1] AOI22X1TS
XU1412 n879 FE_DBTN111_n50 requesterAddressIn_WEST[1] n35
+ requesterAddressIn_EAST[1] AOI22X1TS
XU1415 n878 n43 requesterAddressIn_SOUTH[1] FE_DBTN109_n62
+ requesterAddressIn_NORTH[1] AOI22X1TS
XU1418 n885 n36 readRequesterAddress[2] FE_DBTN110_n1533
+ requesterAddressbuffer[7][2] AOI22X1TS
XU1419 n884 FE_DBTN111_n50 requesterAddressIn_WEST[2] n35
+ requesterAddressIn_EAST[2] AOI22X1TS
XU1423 n883 n43 requesterAddressIn_SOUTH[2] FE_DBTN109_n62
+ requesterAddressIn_NORTH[2] AOI22X1TS
XU1424 n890 n36 readRequesterAddress[3] FE_DBTN110_n1533
+ requesterAddressbuffer[7][3] AOI22X1TS
XU1426 n889 FE_DBTN111_n50 requesterAddressIn_WEST[3] n35
+ requesterAddressIn_EAST[3] AOI22X1TS
XU1429 n888 n43 requesterAddressIn_SOUTH[3] FE_DBTN109_n62
+ requesterAddressIn_NORTH[3] AOI22X1TS
XU1432 n893 readRequesterAddress[0] n80 FE_DBTN106_n1479
+ requesterAddressbuffer[6][0] AOI22X1TS
XU1434 n892 requesterAddressIn_WEST[0] FE_DBTN107_n96
+ requesterAddressIn_EAST[0] n78 AOI22X1TS
XU1435 n891 requesterAddressIn_SOUTH[0] n86 requesterAddressIn_NORTH[0] n93
+ AOI22X1TS
XU1437 n897 readRequesterAddress[1] n80 FE_DBTN106_n1479
+ requesterAddressbuffer[6][1] AOI22X1TS
XU1439 n896 requesterAddressIn_WEST[1] FE_DBTN107_n96
+ requesterAddressIn_EAST[1] n78 AOI22X1TS
XU1441 n895 requesterAddressIn_SOUTH[1] n86 requesterAddressIn_NORTH[1] n93
+ AOI22X1TS
XU1445 n902 readRequesterAddress[2] n80 FE_DBTN106_n1479
+ requesterAddressbuffer[6][2] AOI22X1TS
XU1446 n901 requesterAddressIn_WEST[2] FE_DBTN107_n96
+ requesterAddressIn_EAST[2] n78 AOI22X1TS
XU1448 n900 requesterAddressIn_SOUTH[2] n86 requesterAddressIn_NORTH[2] n93
+ AOI22X1TS
XU1450 n907 readRequesterAddress[3] n80 FE_DBTN106_n1479
+ requesterAddressbuffer[6][3] AOI22X1TS
XU1452 n906 requesterAddressIn_WEST[3] FE_DBTN107_n96
+ requesterAddressIn_EAST[3] n78 AOI22X1TS
XU1453 n905 requesterAddressIn_SOUTH[3] n86 requesterAddressIn_NORTH[3] n93
+ AOI22X1TS
XU1455 n910 readRequesterAddress[0] FE_DBTN113_n13 FE_DBTN98_n1444
+ requesterAddressbuffer[5][0] AOI22X1TS
XU1457 n909 requesterAddressIn_WEST[0] FE_DBTN100_n235
+ requesterAddressIn_EAST[0] n216 AOI22X1TS
XU1458 n908 requesterAddressIn_SOUTH[0] FE_DBTN99_n253
+ requesterAddressIn_NORTH[0] FE_DBTN123_n2 AOI22X1TS
XU1459 n914 readRequesterAddress[1] FE_DBTN113_n13 FE_DBTN98_n1444
+ requesterAddressbuffer[5][1] AOI22X1TS
XU1461 n913 requesterAddressIn_WEST[1] FE_DBTN100_n235
+ requesterAddressIn_EAST[1] n216 AOI22X1TS
XU1462 n912 requesterAddressIn_SOUTH[1] FE_DBTN99_n253
+ requesterAddressIn_NORTH[1] FE_DBTN123_n2 AOI22X1TS
XU1465 n917 readRequesterAddress[2] FE_DBTN113_n13 FE_DBTN98_n1444
+ requesterAddressbuffer[5][2] AOI22X1TS
XU1466 n916 requesterAddressIn_WEST[2] FE_DBTN100_n235
+ requesterAddressIn_EAST[2] n216 AOI22X1TS
XU1467 n915 requesterAddressIn_SOUTH[2] FE_DBTN99_n253
+ requesterAddressIn_NORTH[2] FE_DBTN123_n2 AOI22X1TS
XU1469 n924 readRequesterAddress[3] FE_DBTN113_n13 FE_DBTN98_n1444
+ requesterAddressbuffer[5][3] AOI22X1TS
XU1471 n923 requesterAddressIn_WEST[3] FE_DBTN100_n235
+ requesterAddressIn_EAST[3] n216 AOI22X1TS
XU1474 n922 requesterAddressIn_SOUTH[3] FE_DBTN99_n253
+ requesterAddressIn_NORTH[3] FE_DBTN123_n2 AOI22X1TS
XU1476 n931 readRequesterAddress[0] n270 FE_DBTN95_n1413
+ requesterAddressbuffer[4][0] AOI22X1TS
XU1478 n930 requesterAddressIn_WEST[0] FE_DBTN96_n285
+ requesterAddressIn_EAST[0] n268 AOI22X1TS
XU1479 n929 requesterAddressIn_SOUTH[0] FE_DBTN116_n10
+ requesterAddressIn_NORTH[0] FE_DBTN114_n12 AOI22X1TS
XU1481 n937 readRequesterAddress[1] n270 FE_DBTN95_n1413
+ requesterAddressbuffer[4][1] AOI22X1TS
XU1483 n936 requesterAddressIn_WEST[1] FE_DBTN96_n285
+ requesterAddressIn_EAST[1] n268 AOI22X1TS
XU1484 n935 requesterAddressIn_SOUTH[1] FE_DBTN116_n10
+ requesterAddressIn_NORTH[1] FE_DBTN114_n12 AOI22X1TS
XU1488 n942 readRequesterAddress[2] n270 FE_DBTN95_n1413
+ requesterAddressbuffer[4][2] AOI22X1TS
XU1489 n941 requesterAddressIn_WEST[2] FE_DBTN96_n285
+ requesterAddressIn_EAST[2] n268 AOI22X1TS
XU1490 n940 requesterAddressIn_SOUTH[2] FE_DBTN116_n10
+ requesterAddressIn_NORTH[2] FE_DBTN114_n12 AOI22X1TS
XU1493 n949 readRequesterAddress[3] n270 FE_DBTN95_n1413
+ requesterAddressbuffer[4][3] AOI22X1TS
XU1495 n948 requesterAddressIn_WEST[3] FE_DBTN96_n285
+ requesterAddressIn_EAST[3] n268 AOI22X1TS
XU1496 n947 requesterAddressIn_SOUTH[3] FE_DBTN116_n10
+ requesterAddressIn_NORTH[3] FE_DBTN114_n12 AOI22X1TS
XU1499 n956 readRequesterAddress[0] n129 FE_DBTN105_n1384
+ requesterAddressbuffer[3][0] AOI22X1TS
XU1501 n955 requesterAddressIn_WEST[0] n133 requesterAddressIn_EAST[0] n142
+ AOI22X1TS
XU1503 n954 requesterAddressIn_SOUTH[0] n128 requesterAddressIn_NORTH[0]
+ FE_DBTN104_n159 AOI22X1TS
XU1505 n965 readRequesterAddress[1] n129 FE_DBTN105_n1384
+ requesterAddressbuffer[3][1] AOI22X1TS
XU1507 n964 requesterAddressIn_WEST[1] n133 requesterAddressIn_EAST[1] n142
+ AOI22X1TS
XU1508 n963 requesterAddressIn_SOUTH[1] n128 requesterAddressIn_NORTH[1]
+ FE_DBTN104_n159 AOI22X1TS
XU1512 n973 readRequesterAddress[2] n129 FE_DBTN105_n1384
+ requesterAddressbuffer[3][2] AOI22X1TS
XU1513 n972 requesterAddressIn_WEST[2] n133 requesterAddressIn_EAST[2] n142
+ AOI22X1TS
XU1515 n971 requesterAddressIn_SOUTH[2] n128 requesterAddressIn_NORTH[2]
+ FE_DBTN104_n159 AOI22X1TS
XU1517 n979 readRequesterAddress[3] n129 FE_DBTN105_n1384
+ requesterAddressbuffer[3][3] AOI22X1TS
XU1518 n978 requesterAddressIn_WEST[3] n133 requesterAddressIn_EAST[3] n142
+ AOI22X1TS
XU1519 n977 requesterAddressIn_SOUTH[3] n128 requesterAddressIn_NORTH[3]
+ FE_DBTN104_n159 AOI22X1TS
XU1521 n982 readRequesterAddress[0] FE_DBTN115_n11 FE_DBTN102_n1352
+ requesterAddressbuffer[2][0] AOI22X1TS
XU1523 n981 requesterAddressIn_WEST[0] FE_DBTN103_n191
+ requesterAddressIn_EAST[0] n178 AOI22X1TS
XU1524 n980 requesterAddressIn_SOUTH[0] FE_DBTN122_n3
+ requesterAddressIn_NORTH[0] FE_DBTN119_n6 AOI22X1TS
XU1525 n988 readRequesterAddress[1] FE_DBTN115_n11 FE_DBTN102_n1352
+ requesterAddressbuffer[2][1] AOI22X1TS
XU1527 n987 requesterAddressIn_WEST[1] FE_DBTN103_n191
+ requesterAddressIn_EAST[1] n178 AOI22X1TS
XU1530 n986 requesterAddressIn_SOUTH[1] FE_DBTN122_n3
+ requesterAddressIn_NORTH[1] FE_DBTN119_n6 AOI22X1TS
XU1533 n992 readRequesterAddress[2] FE_DBTN115_n11 FE_DBTN102_n1352
+ requesterAddressbuffer[2][2] AOI22X1TS
XU1534 n991 requesterAddressIn_WEST[2] FE_DBTN103_n191
+ requesterAddressIn_EAST[2] n178 AOI22X1TS
XU1535 n990 requesterAddressIn_SOUTH[2] FE_DBTN122_n3
+ requesterAddressIn_NORTH[2] FE_DBTN119_n6 AOI22X1TS
XU1537 n997 readRequesterAddress[3] FE_DBTN115_n11 FE_DBTN102_n1352
+ requesterAddressbuffer[2][3] AOI22X1TS
XU1539 n996 requesterAddressIn_WEST[3] FE_DBTN103_n191
+ requesterAddressIn_EAST[3] n178 AOI22X1TS
XU1540 n995 requesterAddressIn_SOUTH[3] FE_DBTN122_n3
+ requesterAddressIn_NORTH[3] FE_DBTN119_n6 AOI22X1TS
XU1542 n1004 readRequesterAddress[0] n310 FE_DBTN93_n347
+ requesterAddressbuffer[1][0] AOI22X1TS
XU1544 n1003 requesterAddressIn_WEST[0] FE_DBTN94_n334
+ requesterAddressIn_EAST[0] n308 AOI22X1TS
XU1545 n1002 requesterAddressIn_SOUTH[0] FE_DBTN121_n4
+ requesterAddressIn_NORTH[0] FE_DBTN118_n7 AOI22X1TS
XU1546 n1013 readRequesterAddress[1] n310 FE_DBTN93_n347
+ requesterAddressbuffer[1][1] AOI22X1TS
XU1548 n1012 requesterAddressIn_WEST[1] FE_DBTN94_n334
+ requesterAddressIn_EAST[1] n308 AOI22X1TS
XU1551 n1011 requesterAddressIn_SOUTH[1] FE_DBTN121_n4
+ requesterAddressIn_NORTH[1] FE_DBTN118_n7 AOI22X1TS
XU1554 n1021 readRequesterAddress[2] n310 FE_DBTN93_n347
+ requesterAddressbuffer[1][2] AOI22X1TS
XU1555 n1020 requesterAddressIn_WEST[2] FE_DBTN94_n334
+ requesterAddressIn_EAST[2] n308 AOI22X1TS
XU1556 n1019 requesterAddressIn_SOUTH[2] FE_DBTN121_n4
+ requesterAddressIn_NORTH[2] FE_DBTN118_n7 AOI22X1TS
XU1558 n1029 readRequesterAddress[3] n310 FE_DBTN93_n347
+ requesterAddressbuffer[1][3] AOI22X1TS
XU1560 n1028 requesterAddressIn_WEST[3] FE_DBTN94_n334
+ requesterAddressIn_EAST[3] n308 AOI22X1TS
XU1561 n1027 requesterAddressIn_SOUTH[3] FE_DBTN121_n4
+ requesterAddressIn_NORTH[3] FE_DBTN118_n7 AOI22X1TS
XU1563 n1036 readRequesterAddress[0] FE_DBTN112_n14 FE_DBTN90_n419
+ requesterAddressbuffer[0][0] AOI22X1TS
XU1565 n1035 requesterAddressIn_WEST[0] FE_DBTN89_n412
+ requesterAddressIn_EAST[0] n382 AOI22X1TS
XU1568 n1034 requesterAddressIn_SOUTH[0] FE_DBTN124_n1
+ requesterAddressIn_NORTH[0] FE_DBTN120_n5 AOI22X1TS
XU1569 n1042 readRequesterAddress[1] FE_DBTN112_n14 FE_DBTN90_n419
+ requesterAddressbuffer[0][1] AOI22X1TS
XU1571 n1041 requesterAddressIn_WEST[1] FE_DBTN89_n412
+ requesterAddressIn_EAST[1] n382 AOI22X1TS
XU1572 n1040 requesterAddressIn_SOUTH[1] FE_DBTN124_n1
+ requesterAddressIn_NORTH[1] FE_DBTN120_n5 AOI22X1TS
XU1575 n1047 readRequesterAddress[2] FE_DBTN112_n14 FE_DBTN90_n419
+ requesterAddressbuffer[0][2] AOI22X1TS
XU1576 n1046 requesterAddressIn_WEST[2] FE_DBTN89_n412
+ requesterAddressIn_EAST[2] n382 AOI22X1TS
XU1577 n1045 requesterAddressIn_SOUTH[2] FE_DBTN124_n1
+ requesterAddressIn_NORTH[2] FE_DBTN120_n5 AOI22X1TS
XU1579 n1054 readRequesterAddress[3] FE_DBTN112_n14 FE_DBTN90_n419
+ requesterAddressbuffer[0][3] AOI22X1TS
XU1581 n1053 requesterAddressIn_WEST[3] FE_DBTN89_n412
+ requesterAddressIn_EAST[3] n382 AOI22X1TS
XU1582 n1052 requesterAddressIn_SOUTH[3] FE_DBTN124_n1
+ requesterAddressIn_NORTH[3] FE_DBTN120_n5 AOI22X1TS
XU1584 n1058 FE_DBTN112_n14 cacheDataOut[0] FE_DBTN90_n419 dataoutbuffer[0][0]
+ AOI22X1TS
XU1585 n1057 FE_DBTN89_n412 dataIn_WEST[0] n382 dataIn_EAST[0] AOI22X1TS
XU1587 n1056 FE_DBTN124_n1 dataIn_SOUTH[0] FE_DBTN120_n5 dataIn_NORTH[0]
+ AOI22X1TS
XU1589 n1063 FE_DBTN112_n14 cacheDataOut[1] FE_DBTN90_n419 dataoutbuffer[0][1]
+ AOI22X1TS
XU1590 n1062 FE_DBTN89_n412 dataIn_WEST[1] n382 dataIn_EAST[1] AOI22X1TS
XU1592 n1061 FE_DBTN124_n1 dataIn_SOUTH[1] FE_DBTN120_n5 dataIn_NORTH[1]
+ AOI22X1TS
XU1596 n1069 FE_DBTN112_n14 cacheDataOut[2] FE_DBTN90_n419 dataoutbuffer[0][2]
+ AOI22X1TS
XU1597 n1068 FE_DBTN89_n412 dataIn_WEST[2] n382 dataIn_EAST[2] AOI22X1TS
XU1599 n1067 FE_DBTN124_n1 dataIn_SOUTH[2] FE_DBTN120_n5 dataIn_NORTH[2]
+ AOI22X1TS
XU1601 n1072 FE_DBTN112_n14 cacheDataOut[3] FE_DBTN90_n419 dataoutbuffer[0][3]
+ AOI22X1TS
XU1602 n1071 FE_DBTN89_n412 dataIn_WEST[3] n382 dataIn_EAST[3] AOI22X1TS
XU1604 n1070 FE_DBTN124_n1 dataIn_SOUTH[3] FE_DBTN120_n5 dataIn_NORTH[3]
+ AOI22X1TS
XU1606 n1076 FE_DBTN112_n14 cacheDataOut[4] FE_DBTN90_n419 dataoutbuffer[0][4]
+ AOI22X1TS
XU1607 n1075 FE_DBTN89_n412 dataIn_WEST[4] n382 dataIn_EAST[4] AOI22X1TS
XU1609 n1074 FE_DBTN124_n1 dataIn_SOUTH[4] FE_DBTN120_n5 dataIn_NORTH[4]
+ AOI22X1TS
XU1611 n1080 FE_DBTN112_n14 cacheDataOut[5] FE_DBTN90_n419 dataoutbuffer[0][5]
+ AOI22X1TS
XU1612 n1079 FE_DBTN89_n412 dataIn_WEST[5] n382 dataIn_EAST[5] AOI22X1TS
XU1614 n1078 FE_DBTN124_n1 dataIn_SOUTH[5] FE_DBTN120_n5 dataIn_NORTH[5]
+ AOI22X1TS
XU1616 n1085 n310 cacheDataOut[0] FE_DBTN93_n347 dataoutbuffer[1][0] AOI22X1TS
XU1617 n1084 FE_DBTN94_n334 dataIn_WEST[0] n308 dataIn_EAST[0] AOI22X1TS
XU1621 n1083 FE_DBTN118_n7 dataIn_NORTH[0] FE_DBTN121_n4 dataIn_SOUTH[0]
+ AOI22X1TS
XU1623 n1091 n310 cacheDataOut[1] FE_DBTN93_n347 dataoutbuffer[1][1] AOI22X1TS
XU1624 n1090 FE_DBTN94_n334 dataIn_WEST[1] n308 dataIn_EAST[1] AOI22X1TS
XU1628 n1089 FE_DBTN118_n7 dataIn_NORTH[1] FE_DBTN121_n4 dataIn_SOUTH[1]
+ AOI22X1TS
XU1631 n1100 n310 cacheDataOut[2] FE_DBTN93_n347 dataoutbuffer[1][2] AOI22X1TS
XU1632 n1099 FE_DBTN94_n334 dataIn_WEST[2] n308 dataIn_EAST[2] AOI22X1TS
XU1636 n1098 FE_DBTN118_n7 dataIn_NORTH[2] FE_DBTN121_n4 dataIn_SOUTH[2]
+ AOI22X1TS
XU1638 n1106 n310 cacheDataOut[3] FE_DBTN93_n347 dataoutbuffer[1][3] AOI22X1TS
XU1639 n1105 FE_DBTN94_n334 dataIn_WEST[3] n308 dataIn_EAST[3] AOI22X1TS
XU1643 n1104 FE_DBTN118_n7 dataIn_NORTH[3] FE_DBTN121_n4 dataIn_SOUTH[3]
+ AOI22X1TS
XU1645 n1111 n310 cacheDataOut[4] FE_DBTN93_n347 dataoutbuffer[1][4] AOI22X1TS
XU1646 n1110 FE_DBTN94_n334 dataIn_WEST[4] n308 dataIn_EAST[4] AOI22X1TS
XU1650 n1109 FE_DBTN118_n7 dataIn_NORTH[4] FE_DBTN121_n4 dataIn_SOUTH[4]
+ AOI22X1TS
XU1652 n1342 n310 cacheDataOut[5] FE_DBTN93_n347 dataoutbuffer[1][5] AOI22X1TS
XU1653 n1341 FE_DBTN94_n334 dataIn_WEST[5] n308 dataIn_EAST[5] AOI22X1TS
XU1657 n1340 FE_DBTN118_n7 dataIn_NORTH[5] FE_DBTN121_n4 dataIn_SOUTH[5]
+ AOI22X1TS
XU1658 n1346 FE_DBTN115_n11 cacheDataOut[0] FE_DBTN102_n1352
+ dataoutbuffer[2][0] AOI22X1TS
XU1659 n1345 FE_DBTN103_n191 dataIn_WEST[0] n178 dataIn_EAST[0] AOI22X1TS
XU1660 n1344 FE_DBTN119_n6 dataIn_NORTH[0] FE_DBTN122_n3 dataIn_SOUTH[0]
+ AOI22X1TS
XU1661 n1351 FE_DBTN115_n11 cacheDataOut[1] FE_DBTN102_n1352
+ dataoutbuffer[2][1] AOI22X1TS
XU1662 n1350 FE_DBTN103_n191 dataIn_WEST[1] n178 dataIn_EAST[1] AOI22X1TS
XU1664 n1349 FE_DBTN119_n6 dataIn_NORTH[1] FE_DBTN122_n3 dataIn_SOUTH[1]
+ AOI22X1TS
XU1667 n1358 FE_DBTN115_n11 cacheDataOut[2] FE_DBTN102_n1352
+ dataoutbuffer[2][2] AOI22X1TS
XU1668 n1357 FE_DBTN103_n191 dataIn_WEST[2] n178 dataIn_EAST[2] AOI22X1TS
XU1669 n1356 FE_DBTN119_n6 dataIn_NORTH[2] FE_DBTN122_n3 dataIn_SOUTH[2]
+ AOI22X1TS
XU1670 n1363 FE_DBTN115_n11 cacheDataOut[3] FE_DBTN102_n1352
+ dataoutbuffer[2][3] AOI22X1TS
XU1671 n1362 FE_DBTN103_n191 dataIn_WEST[3] n178 dataIn_EAST[3] AOI22X1TS
XU1672 n1361 FE_DBTN119_n6 dataIn_NORTH[3] FE_DBTN122_n3 dataIn_SOUTH[3]
+ AOI22X1TS
XU1673 n1367 FE_DBTN115_n11 cacheDataOut[4] FE_DBTN102_n1352
+ dataoutbuffer[2][4] AOI22X1TS
XU1674 n1366 FE_DBTN103_n191 dataIn_WEST[4] n178 dataIn_EAST[4] AOI22X1TS
XU1675 n1365 FE_DBTN119_n6 dataIn_NORTH[4] FE_DBTN122_n3 dataIn_SOUTH[4]
+ AOI22X1TS
XU1676 n1373 FE_DBTN115_n11 cacheDataOut[5] FE_DBTN102_n1352
+ dataoutbuffer[2][5] AOI22X1TS
XU1677 n1372 FE_DBTN103_n191 dataIn_WEST[5] n178 dataIn_EAST[5] AOI22X1TS
XU1678 n1371 FE_DBTN119_n6 dataIn_NORTH[5] FE_DBTN122_n3 dataIn_SOUTH[5]
+ AOI22X1TS
XU1679 n1377 n129 cacheDataOut[0] FE_DBTN105_n1384 dataoutbuffer[3][0]
+ AOI22X1TS
XU1680 n1376 n133 dataIn_WEST[0] n142 dataIn_EAST[0] AOI22X1TS
XU1681 n1375 FE_DBTN104_n159 dataIn_NORTH[0] n128 dataIn_SOUTH[0] AOI22X1TS
XU1682 n1382 n129 cacheDataOut[1] FE_DBTN105_n1384 dataoutbuffer[3][1]
+ AOI22X1TS
XU1683 n1381 n133 dataIn_WEST[1] n142 dataIn_EAST[1] AOI22X1TS
XU1684 n1380 FE_DBTN104_n159 dataIn_NORTH[1] n128 dataIn_SOUTH[1] AOI22X1TS
XU1687 n1387 n129 cacheDataOut[2] FE_DBTN105_n1384 dataoutbuffer[3][2]
+ AOI22X1TS
XU1688 n1386 n133 dataIn_WEST[2] n142 dataIn_EAST[2] AOI22X1TS
XU1689 n1385 FE_DBTN104_n159 dataIn_NORTH[2] n128 dataIn_SOUTH[2] AOI22X1TS
XU1690 n1390 n129 cacheDataOut[3] FE_DBTN105_n1384 dataoutbuffer[3][3]
+ AOI22X1TS
XU1691 n1389 n133 dataIn_WEST[3] n142 dataIn_EAST[3] AOI22X1TS
XU1692 n1388 FE_DBTN104_n159 dataIn_NORTH[3] n128 dataIn_SOUTH[3] AOI22X1TS
XU1693 n1396 n129 cacheDataOut[4] FE_DBTN105_n1384 dataoutbuffer[3][4]
+ AOI22X1TS
XU1694 n1395 n133 dataIn_WEST[4] n142 dataIn_EAST[4] AOI22X1TS
XU1695 n1394 FE_DBTN104_n159 dataIn_NORTH[4] n128 dataIn_SOUTH[4] AOI22X1TS
XU1696 n1401 n129 cacheDataOut[5] FE_DBTN105_n1384 dataoutbuffer[3][5]
+ AOI22X1TS
XU1697 n1400 n133 dataIn_WEST[5] n142 dataIn_EAST[5] AOI22X1TS
XU1698 n1399 FE_DBTN104_n159 dataIn_NORTH[5] n128 dataIn_SOUTH[5] AOI22X1TS
XU1699 n1406 n270 cacheDataOut[0] FE_DBTN95_n1413 dataoutbuffer[4][0] AOI22X1TS
XU1700 n1405 FE_DBTN96_n285 dataIn_WEST[0] n268 dataIn_EAST[0] AOI22X1TS
XU1701 n1404 FE_DBTN116_n10 dataIn_SOUTH[0] FE_DBTN114_n12 dataIn_NORTH[0]
+ AOI22X1TS
XU1702 n1411 n270 cacheDataOut[1] FE_DBTN95_n1413 dataoutbuffer[4][1] AOI22X1TS
XU1703 n1410 FE_DBTN96_n285 dataIn_WEST[1] n268 dataIn_EAST[1] AOI22X1TS
XU1704 n1409 FE_DBTN116_n10 dataIn_SOUTH[1] FE_DBTN114_n12 dataIn_NORTH[1]
+ AOI22X1TS
XU1706 n1420 n270 cacheDataOut[2] FE_DBTN95_n1413 dataoutbuffer[4][2] AOI22X1TS
XU1707 n1419 FE_DBTN96_n285 dataIn_WEST[2] n268 dataIn_EAST[2] AOI22X1TS
XU1708 n1418 FE_DBTN116_n10 dataIn_SOUTH[2] FE_DBTN114_n12 dataIn_NORTH[2]
+ AOI22X1TS
XU1709 n1424 n270 cacheDataOut[3] FE_DBTN95_n1413 dataoutbuffer[4][3] AOI22X1TS
XU1710 n1423 FE_DBTN96_n285 dataIn_WEST[3] n268 dataIn_EAST[3] AOI22X1TS
XU1711 n1422 FE_DBTN116_n10 dataIn_SOUTH[3] FE_DBTN114_n12 dataIn_NORTH[3]
+ AOI22X1TS
XU1712 n1428 n270 cacheDataOut[4] FE_DBTN95_n1413 dataoutbuffer[4][4] AOI22X1TS
XU1713 n1427 FE_DBTN96_n285 dataIn_WEST[4] n268 dataIn_EAST[4] AOI22X1TS
XU1714 n1426 FE_DBTN116_n10 dataIn_SOUTH[4] FE_DBTN114_n12 dataIn_NORTH[4]
+ AOI22X1TS
XU1715 n1434 n270 cacheDataOut[5] FE_DBTN95_n1413 dataoutbuffer[4][5] AOI22X1TS
XU1716 n1433 FE_DBTN96_n285 dataIn_WEST[5] n268 dataIn_EAST[5] AOI22X1TS
XU1717 n1432 FE_DBTN116_n10 dataIn_SOUTH[5] FE_DBTN114_n12 dataIn_NORTH[5]
+ AOI22X1TS
XU1718 n1438 FE_DBTN113_n13 cacheDataOut[0] FE_DBTN98_n1444 dataoutbuffer[5][0]
+ AOI22X1TS
XU1719 n1437 FE_DBTN100_n235 dataIn_WEST[0] n216 dataIn_EAST[0] AOI22X1TS
XU1720 n1436 FE_DBTN123_n2 dataIn_NORTH[0] FE_DBTN99_n253 dataIn_SOUTH[0]
+ AOI22X1TS
XU1721 n1443 FE_DBTN113_n13 cacheDataOut[1] FE_DBTN98_n1444 dataoutbuffer[5][1]
+ AOI22X1TS
XU1722 n1442 FE_DBTN100_n235 dataIn_WEST[1] n216 dataIn_EAST[1] AOI22X1TS
XU1723 n1441 FE_DBTN123_n2 dataIn_NORTH[1] FE_DBTN99_n253 dataIn_SOUTH[1]
+ AOI22X1TS
XU1726 n1448 FE_DBTN113_n13 cacheDataOut[2] FE_DBTN98_n1444 dataoutbuffer[5][2]
+ AOI22X1TS
XU1727 n1447 FE_DBTN100_n235 dataIn_WEST[2] n216 dataIn_EAST[2] AOI22X1TS
XU1728 n1446 FE_DBTN123_n2 dataIn_NORTH[2] FE_DBTN99_n253 dataIn_SOUTH[2]
+ AOI22X1TS
XU1729 n1452 FE_DBTN113_n13 cacheDataOut[3] FE_DBTN98_n1444 dataoutbuffer[5][3]
+ AOI22X1TS
XU1730 n1451 FE_DBTN100_n235 dataIn_WEST[3] n216 dataIn_EAST[3] AOI22X1TS
XU1731 n1450 FE_DBTN123_n2 dataIn_NORTH[3] FE_DBTN99_n253 dataIn_SOUTH[3]
+ AOI22X1TS
XU1732 n1455 FE_DBTN113_n13 cacheDataOut[4] FE_DBTN98_n1444 dataoutbuffer[5][4]
+ AOI22X1TS
XU1733 n1454 FE_DBTN100_n235 dataIn_WEST[4] n216 dataIn_EAST[4] AOI22X1TS
XU1734 n1453 FE_DBTN123_n2 dataIn_NORTH[4] FE_DBTN99_n253 dataIn_SOUTH[4]
+ AOI22X1TS
XU1735 n1460 FE_DBTN113_n13 cacheDataOut[5] FE_DBTN98_n1444 dataoutbuffer[5][5]
+ AOI22X1TS
XU1736 n1459 FE_DBTN100_n235 dataIn_WEST[5] n216 dataIn_EAST[5] AOI22X1TS
XU1737 n1458 FE_DBTN123_n2 dataIn_NORTH[5] FE_DBTN99_n253 dataIn_SOUTH[5]
+ AOI22X1TS
XU1738 n1468 n80 cacheDataOut[0] FE_DBTN106_n1479 dataoutbuffer[6][0] AOI22X1TS
XU1739 n1467 FE_DBTN107_n96 dataIn_WEST[0] n78 dataIn_EAST[0] AOI22X1TS
XU1740 n1466 n93 dataIn_NORTH[0] n86 dataIn_SOUTH[0] AOI22X1TS
XU1741 n1477 n80 cacheDataOut[1] FE_DBTN106_n1479 dataoutbuffer[6][1] AOI22X1TS
XU1742 n1476 FE_DBTN107_n96 dataIn_WEST[1] n78 dataIn_EAST[1] AOI22X1TS
XU1744 n1475 n93 dataIn_NORTH[1] n86 dataIn_SOUTH[1] AOI22X1TS
XU1747 n1489 n80 cacheDataOut[2] FE_DBTN106_n1479 dataoutbuffer[6][2] AOI22X1TS
XU1748 n1488 FE_DBTN107_n96 dataIn_WEST[2] n78 dataIn_EAST[2] AOI22X1TS
XU1749 n1487 n93 dataIn_NORTH[2] n86 dataIn_SOUTH[2] AOI22X1TS
XU1750 n1497 n80 cacheDataOut[3] FE_DBTN106_n1479 dataoutbuffer[6][3] AOI22X1TS
XU1751 n1496 FE_DBTN107_n96 dataIn_WEST[3] n78 dataIn_EAST[3] AOI22X1TS
XU1752 n1495 n93 dataIn_NORTH[3] n86 dataIn_SOUTH[3] AOI22X1TS
XU1753 n1504 n80 cacheDataOut[4] FE_DBTN106_n1479 dataoutbuffer[6][4] AOI22X1TS
XU1754 n1503 FE_DBTN107_n96 dataIn_WEST[4] n78 dataIn_EAST[4] AOI22X1TS
XU1755 n1502 n93 dataIn_NORTH[4] n86 dataIn_SOUTH[4] AOI22X1TS
XU1756 n1513 n80 cacheDataOut[5] FE_DBTN106_n1479 dataoutbuffer[6][5] AOI22X1TS
XU1757 n1512 FE_DBTN107_n96 dataIn_WEST[5] n78 dataIn_EAST[5] AOI22X1TS
XU1758 n1511 n93 dataIn_NORTH[5] n86 dataIn_SOUTH[5] AOI22X1TS
XU1759 n1522 n36 cacheDataOut[0] FE_DBTN110_n1533 dataoutbuffer[7][0] AOI22X1TS
XU1760 n1521 FE_DBTN111_n50 dataIn_WEST[0] n35 dataIn_EAST[0] AOI22X1TS
XU1761 n1520 n43 dataIn_SOUTH[0] FE_DBTN109_n62 dataIn_NORTH[0] AOI22X1TS
XU1762 n1532 n36 cacheDataOut[1] FE_DBTN110_n1533 dataoutbuffer[7][1] AOI22X1TS
XU1763 n1531 FE_DBTN111_n50 dataIn_WEST[1] n35 dataIn_EAST[1] AOI22X1TS
XU1765 n1530 n43 dataIn_SOUTH[1] FE_DBTN109_n62 dataIn_NORTH[1] AOI22X1TS
XU1767 n1540 n36 cacheDataOut[2] FE_DBTN110_n1533 dataoutbuffer[7][2] AOI22X1TS
XU1768 n1539 FE_DBTN111_n50 dataIn_WEST[2] n35 dataIn_EAST[2] AOI22X1TS
XU1769 n1538 n43 dataIn_SOUTH[2] FE_DBTN109_n62 dataIn_NORTH[2] AOI22X1TS
XU1770 n1547 n36 cacheDataOut[3] FE_DBTN110_n1533 dataoutbuffer[7][3] AOI22X1TS
XU1771 n1546 FE_DBTN111_n50 dataIn_WEST[3] n35 dataIn_EAST[3] AOI22X1TS
XU1772 n1545 n43 dataIn_SOUTH[3] FE_DBTN109_n62 dataIn_NORTH[3] AOI22X1TS
XU1773 n1555 n36 cacheDataOut[4] FE_DBTN110_n1533 dataoutbuffer[7][4] AOI22X1TS
XU1774 n1554 FE_DBTN111_n50 dataIn_WEST[4] n35 dataIn_EAST[4] AOI22X1TS
XU1775 n1553 n43 dataIn_SOUTH[4] FE_DBTN109_n62 dataIn_NORTH[4] AOI22X1TS
XU1776 n1563 n36 cacheDataOut[5] FE_DBTN110_n1533 dataoutbuffer[7][5] AOI22X1TS
XU1777 n1562 FE_DBTN111_n50 dataIn_WEST[5] n35 dataIn_EAST[5] AOI22X1TS
XU1778 n1561 n43 dataIn_SOUTH[5] FE_DBTN109_n62 dataIn_NORTH[5] AOI22X1TS
XU1781 n1568 n1566 readIn_SOUTH readIn_NORTH n1565 AOI22X1TS
XU1782 n1571 n1569 FE_DBTN218_readInBuffer_EAST n1568 n1567 AOI22X1TS
XU1783 n1575 n1572 readIn_WEST n1571 n1570 AOI22X1TS
XU1784 n2075 n1575 n1533 n1573 FE_DBTN110_n1533 n1948 AOI32X1TS
XU1786 n1579 n1577 readIn_SOUTH readIn_NORTH n1576 AOI22X1TS
XU1787 n1582 n1580 FE_DBTN218_readInBuffer_EAST n1579 n1578 AOI22X1TS
XU1788 n1586 n1583 readIn_WEST n1582 n1581 AOI22X1TS
XU1789 n2076 n1586 n1479 n1584 FE_DBTN106_n1479 n1949 AOI32X1TS
XU1790 n1592 n1590 readIn_SOUTH readIn_NORTH n1587 AOI22X1TS
XU1791 n1595 n1593 FE_DBTN218_readInBuffer_EAST n1592 n1591 AOI22X1TS
XU1792 n1599 n1596 readIn_WEST n1595 n1594 AOI22X1TS
XU1793 n2077 n1599 n1444 n1597 FE_DBTN98_n1444 n1950 AOI32X1TS
XU1795 n1603 n1601 readIn_SOUTH readIn_NORTH n1600 AOI22X1TS
XU1796 n1606 n1604 FE_DBTN218_readInBuffer_EAST n1603 n1602 AOI22X1TS
XU1797 n1611 n1608 readIn_WEST n1606 n1605 AOI22X1TS
XU1798 n2078 n1611 n1413 n1609 FE_DBTN95_n1413 n1951 AOI32X1TS
XU1799 n1613 n119 readIn_SOUTH readIn_NORTH n29 AOI22X1TS
XU1800 n1616 n1614 FE_DBTN218_readInBuffer_EAST n1613 n1612 AOI22X1TS
XU1801 n1620 n1617 readIn_WEST n1616 n1615 AOI22X1TS
XU1802 n2079 n1620 n1384 n1618 FE_DBTN105_n1384 n1952 AOI32X1TS
XU1803 n1625 n1623 readIn_SOUTH readIn_NORTH n1621 AOI22X1TS
XU1804 n1629 n1627 FE_DBTN218_readInBuffer_EAST n1625 n1624 AOI22X1TS
XU1805 n1633 n1630 readIn_WEST n1629 n1628 AOI22X1TS
XU1806 n2080 n1633 n1352 n1631 FE_DBTN102_n1352 n1953 AOI32X1TS
XU1807 n1638 n1636 readIn_SOUTH readIn_NORTH n1634 AOI22X1TS
XU1808 n1641 n1639 FE_DBTN218_readInBuffer_EAST n1638 n1637 AOI22X1TS
XU1809 n1645 n1643 readIn_WEST n1641 n1640 AOI22X1TS
XU1810 n2081 n1645 n347 n1644 FE_DBTN93_n347 n1954 AOI32X1TS
XU1811 n1650 n1648 readIn_SOUTH readIn_NORTH n1646 AOI22X1TS
XU1812 n1654 n1652 FE_DBTN218_readInBuffer_EAST n1650 n1649 AOI22X1TS
XU1813 n1658 n1656 readIn_WEST n1654 n1653 AOI22X1TS
XU1814 n2082 n1658 n419 n1657 FE_DBTN90_n419 n1955 AOI32X1TS
XU1815 n1664 readRequesterAddress[0] n36 FE_DBTN110_n1533
+ destinationAddressbuffer[7][0] AOI22X1TS
XU1816 n1663 FE_DBTN111_n50 destinationAddressIn_WEST[0] n35
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1818 n1662 n43 destinationAddressIn_SOUTH[0] FE_DBTN109_n62
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1819 n1673 n36 readRequesterAddress[1] FE_DBTN110_n1533
+ destinationAddressbuffer[7][1] AOI22X1TS
XU1820 n1672 FE_DBTN111_n50 destinationAddressIn_WEST[1] n35
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1822 n1671 n43 destinationAddressIn_SOUTH[1] FE_DBTN109_n62
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1823 n1680 n36 readRequesterAddress[2] FE_DBTN110_n1533
+ destinationAddressbuffer[7][2] AOI22X1TS
XU1824 n1679 FE_DBTN111_n50 destinationAddressIn_WEST[2] n35
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1826 n1678 n43 destinationAddressIn_SOUTH[2] FE_DBTN109_n62
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1827 n1688 n36 readRequesterAddress[3] FE_DBTN110_n1533
+ destinationAddressbuffer[7][3] AOI22X1TS
XU1828 n1687 FE_DBTN111_n50 destinationAddressIn_WEST[3] n35
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1830 n1686 n43 destinationAddressIn_SOUTH[3] FE_DBTN109_n62
+ destinationAddressIn_NORTH[3] AOI22X1TS
XU1831 n1693 readRequesterAddress[0] n80 FE_DBTN106_n1479
+ destinationAddressbuffer[6][0] AOI22X1TS
XU1832 n1692 FE_DBTN107_n96 destinationAddressIn_WEST[0] n78
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1836 n1691 n93 destinationAddressIn_NORTH[0] n86
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1837 n1701 readRequesterAddress[1] n80 FE_DBTN106_n1479
+ destinationAddressbuffer[6][1] AOI22X1TS
XU1838 n1700 FE_DBTN107_n96 destinationAddressIn_WEST[1] n78
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1842 n1699 n93 destinationAddressIn_NORTH[1] n86
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1843 n1708 readRequesterAddress[2] n80 FE_DBTN106_n1479
+ destinationAddressbuffer[6][2] AOI22X1TS
XU1844 n1707 FE_DBTN107_n96 destinationAddressIn_WEST[2] n78
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1848 n1706 n93 destinationAddressIn_NORTH[2] n86
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1849 n1716 readRequesterAddress[3] n80 FE_DBTN106_n1479
+ destinationAddressbuffer[6][3] AOI22X1TS
XU1850 n1715 FE_DBTN107_n96 destinationAddressIn_WEST[3] n78
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1854 n1714 n93 destinationAddressIn_NORTH[3] n86
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1855 n1722 readRequesterAddress[0] FE_DBTN113_n13 FE_DBTN98_n1444
+ destinationAddressbuffer[5][0] AOI22X1TS
XU1856 n1721 FE_DBTN100_n235 destinationAddressIn_WEST[0] n216
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1857 n1720 FE_DBTN123_n2 destinationAddressIn_NORTH[0] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1858 n1730 readRequesterAddress[1] FE_DBTN113_n13 FE_DBTN98_n1444
+ destinationAddressbuffer[5][1] AOI22X1TS
XU1859 n1729 FE_DBTN100_n235 destinationAddressIn_WEST[1] n216
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1860 n1728 FE_DBTN123_n2 destinationAddressIn_NORTH[1] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1861 n1741 readRequesterAddress[2] FE_DBTN113_n13 FE_DBTN98_n1444
+ destinationAddressbuffer[5][2] AOI22X1TS
XU1862 n1740 FE_DBTN100_n235 destinationAddressIn_WEST[2] n216
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1863 n1739 FE_DBTN123_n2 destinationAddressIn_NORTH[2] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1864 n1750 readRequesterAddress[3] FE_DBTN113_n13 FE_DBTN98_n1444
+ destinationAddressbuffer[5][3] AOI22X1TS
XU1865 n1749 FE_DBTN100_n235 destinationAddressIn_WEST[3] n216
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1866 n1748 FE_DBTN123_n2 destinationAddressIn_NORTH[3] FE_DBTN99_n253
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1867 n1755 readRequesterAddress[0] n270 FE_DBTN95_n1413
+ destinationAddressbuffer[4][0] AOI22X1TS
XU1868 n1754 FE_DBTN96_n285 destinationAddressIn_WEST[0] n268
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1869 n1753 FE_DBTN116_n10 destinationAddressIn_SOUTH[0] FE_DBTN114_n12
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1870 n1763 readRequesterAddress[1] n270 FE_DBTN95_n1413
+ destinationAddressbuffer[4][1] AOI22X1TS
XU1871 n1762 FE_DBTN96_n285 destinationAddressIn_WEST[1] n268
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1872 n1761 FE_DBTN116_n10 destinationAddressIn_SOUTH[1] FE_DBTN114_n12
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1873 n1773 readRequesterAddress[2] n270 FE_DBTN95_n1413
+ destinationAddressbuffer[4][2] AOI22X1TS
XU1874 n1772 FE_DBTN96_n285 destinationAddressIn_WEST[2] n268
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1875 n1771 FE_DBTN116_n10 destinationAddressIn_SOUTH[2] FE_DBTN114_n12
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1876 n1779 readRequesterAddress[3] n270 FE_DBTN95_n1413
+ destinationAddressbuffer[4][3] AOI22X1TS
XU1877 n1778 FE_DBTN96_n285 destinationAddressIn_WEST[3] n268
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1878 n1777 FE_DBTN116_n10 destinationAddressIn_SOUTH[3] FE_DBTN114_n12
+ destinationAddressIn_NORTH[3] AOI22X1TS
XU1879 n1785 readRequesterAddress[0] n129 FE_DBTN105_n1384
+ destinationAddressbuffer[3][0] AOI22X1TS
XU1880 n1784 n133 destinationAddressIn_WEST[0] n142
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1881 n1783 FE_DBTN104_n159 destinationAddressIn_NORTH[0] n128
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1882 n1793 readRequesterAddress[1] n129 FE_DBTN105_n1384
+ destinationAddressbuffer[3][1] AOI22X1TS
XU1883 n1792 n133 destinationAddressIn_WEST[1] n142
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1884 n1791 FE_DBTN104_n159 destinationAddressIn_NORTH[1] n128
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1885 n1799 readRequesterAddress[2] n129 FE_DBTN105_n1384
+ destinationAddressbuffer[3][2] AOI22X1TS
XU1886 n1798 n133 destinationAddressIn_WEST[2] n142
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1887 n1797 FE_DBTN104_n159 destinationAddressIn_NORTH[2] n128
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1888 n1808 readRequesterAddress[3] n129 FE_DBTN105_n1384
+ destinationAddressbuffer[3][3] AOI22X1TS
XU1889 n1807 n133 destinationAddressIn_WEST[3] n142
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1890 n1806 FE_DBTN104_n159 destinationAddressIn_NORTH[3] n128
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1891 n1813 readRequesterAddress[0] FE_DBTN115_n11 FE_DBTN102_n1352
+ destinationAddressbuffer[2][0] AOI22X1TS
XU1892 n1812 FE_DBTN103_n191 destinationAddressIn_WEST[0] n178
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1893 n1811 FE_DBTN119_n6 destinationAddressIn_NORTH[0] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1894 n1820 readRequesterAddress[1] FE_DBTN115_n11 FE_DBTN102_n1352
+ destinationAddressbuffer[2][1] AOI22X1TS
XU1895 n1819 FE_DBTN103_n191 destinationAddressIn_WEST[1] n178
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1896 n1818 FE_DBTN119_n6 destinationAddressIn_NORTH[1] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1897 n1829 readRequesterAddress[2] FE_DBTN115_n11 FE_DBTN102_n1352
+ destinationAddressbuffer[2][2] AOI22X1TS
XU1898 n1828 FE_DBTN103_n191 destinationAddressIn_WEST[2] n178
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1899 n1827 FE_DBTN119_n6 destinationAddressIn_NORTH[2] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1900 n1836 readRequesterAddress[3] FE_DBTN115_n11 FE_DBTN102_n1352
+ destinationAddressbuffer[2][3] AOI22X1TS
XU1901 n1835 FE_DBTN103_n191 destinationAddressIn_WEST[3] n178
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1902 n1834 FE_DBTN119_n6 destinationAddressIn_NORTH[3] FE_DBTN122_n3
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1903 n1844 readRequesterAddress[0] n310 FE_DBTN93_n347
+ destinationAddressbuffer[1][0] AOI22X1TS
XU1904 n1843 FE_DBTN94_n334 destinationAddressIn_WEST[0] n308
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1905 n1842 FE_DBTN118_n7 destinationAddressIn_NORTH[0] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[0] AOI22X1TS
XU1906 n1855 readRequesterAddress[1] n310 FE_DBTN93_n347
+ destinationAddressbuffer[1][1] AOI22X1TS
XU1907 n1854 FE_DBTN94_n334 destinationAddressIn_WEST[1] n308
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1908 n1853 FE_DBTN118_n7 destinationAddressIn_NORTH[1] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[1] AOI22X1TS
XU1909 n1868 readRequesterAddress[2] n310 FE_DBTN93_n347
+ destinationAddressbuffer[1][2] AOI22X1TS
XU1910 n1867 FE_DBTN94_n334 destinationAddressIn_WEST[2] n308
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1911 n1866 FE_DBTN118_n7 destinationAddressIn_NORTH[2] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[2] AOI22X1TS
XU1912 n1878 readRequesterAddress[3] n310 FE_DBTN93_n347
+ destinationAddressbuffer[1][3] AOI22X1TS
XU1913 n1877 FE_DBTN94_n334 destinationAddressIn_WEST[3] n308
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1914 n1876 FE_DBTN118_n7 destinationAddressIn_NORTH[3] FE_DBTN121_n4
+ destinationAddressIn_SOUTH[3] AOI22X1TS
XU1915 n1886 readRequesterAddress[0] FE_DBTN112_n14 FE_DBTN90_n419
+ destinationAddressbuffer[0][0] AOI22X1TS
XU1916 n1885 FE_DBTN89_n412 destinationAddressIn_WEST[0] n382
+ destinationAddressIn_EAST[0] AOI22X1TS
XU1917 n1884 FE_DBTN124_n1 destinationAddressIn_SOUTH[0] FE_DBTN120_n5
+ destinationAddressIn_NORTH[0] AOI22X1TS
XU1918 n1896 readRequesterAddress[1] FE_DBTN112_n14 FE_DBTN90_n419
+ destinationAddressbuffer[0][1] AOI22X1TS
XU1919 n1895 FE_DBTN89_n412 destinationAddressIn_WEST[1] n382
+ destinationAddressIn_EAST[1] AOI22X1TS
XU1920 n1894 FE_DBTN124_n1 destinationAddressIn_SOUTH[1] FE_DBTN120_n5
+ destinationAddressIn_NORTH[1] AOI22X1TS
XU1921 n1908 readRequesterAddress[2] FE_DBTN112_n14 FE_DBTN90_n419
+ destinationAddressbuffer[0][2] AOI22X1TS
XU1922 n1907 FE_DBTN89_n412 destinationAddressIn_WEST[2] n382
+ destinationAddressIn_EAST[2] AOI22X1TS
XU1923 n1906 FE_DBTN124_n1 destinationAddressIn_SOUTH[2] FE_DBTN120_n5
+ destinationAddressIn_NORTH[2] AOI22X1TS
XU1924 n1917 readRequesterAddress[3] FE_DBTN112_n14 FE_DBTN90_n419
+ destinationAddressbuffer[0][3] AOI22X1TS
XU1925 n1916 FE_DBTN89_n412 destinationAddressIn_WEST[3] n382
+ destinationAddressIn_EAST[3] AOI22X1TS
XU1926 n1915 FE_DBTN124_n1 destinationAddressIn_SOUTH[3] FE_DBTN120_n5
+ destinationAddressIn_NORTH[3] AOI22X1TS
.ENDS

.SUBCKT incomingPortHandler_1 clk reset localRouterAddress[3]
+ localRouterAddress[2] localRouterAddress[1] localRouterAddress[0]
+ destinationAddressIn[11] destinationAddressIn[10] destinationAddressIn[9]
+ destinationAddressIn[8] destinationAddressIn[7] destinationAddressIn[6]
+ destinationAddressIn[5] destinationAddressIn[4] destinationAddressIn[3]
+ destinationAddressIn[2] destinationAddressIn[1] destinationAddressIn[0]
+ requesterAddressIn[3] requesterAddressIn[2] requesterAddressIn[1]
+ requesterAddressIn[0] readIn writeIn outputPortSelect[3] outputPortSelect[2]
+ outputPortSelect[1] outputPortSelect[0] memRead memWrite
XmemRead_reg memRead clk n19 DFFQX1TS
XmemWrite_reg memWrite clk n27 DFFQX1TS
XoutputPortSelect_reg[3] outputPortSelect[3] clk n20 DFFQX1TS
XoutputPortSelect_reg[2] outputPortSelect[2] clk n21 DFFQX1TS
XoutputPortSelect_reg[1] outputPortSelect[1] clk n25 DFFQX1TS
XoutputPortSelect_reg[0] outputPortSelect[0] clk n26 DFFQX1TS
XU4 n5 localRouterAddress[3] destinationAddressIn[11] NAND2BXLTS
XU5 n3 localRouterAddress[2] destinationAddressIn[10] NOR2BX1TS
XU6 n2 localRouterAddress[3] destinationAddressIn[11] NOR2BX1TS
XU7 n1 n5 n3 n2 AOI21X1TS
XU8 n14 readIn writeIn reset AOI2BB1XLTS
XU9 n11 n14 INVX2TS
XU10 n26 n1 n11 NOR2XLTS
XU11 n4 localRouterAddress[2] destinationAddressIn[10] NAND2BXLTS
XU12 n25 n11 n2 n4 n5 n11 OAI32X1TS
XU13 n6 destinationAddressIn[9] INVX2TS
XU14 n7 destinationAddressIn[8] INVX2TS
XU15 n10 localRouterAddress[1] n6 localRouterAddress[0] n7 AOI22X1TS
XU16 n15 n5 n4 n3 n2 NOR4BBXLTS
XU17 n9 localRouterAddress[1] n6 OR2X1TS
XU18 n8 localRouterAddress[0] n7 OR2X1TS
XU19 n13 n10 n15 n9 n8 NAND4XLTS
XU20 n18 reset n13 NOR2XLTS
XU21 n17 reset readIn writeIn NOR3XLTS
XU22 n19 readIn n18 memRead n17 AO22XLTS
XU23 n12 n10 n9 NAND2BXLTS
XU24 n20 n15 n11 n12 NOR3BXLTS
XU25 n21 n15 n14 n13 n12 AND4X1TS
XU26 n27 n18 writeIn n17 memWrite AO22XLTS
.ENDS

.SUBCKT incomingPortHandler_2 clk reset localRouterAddress[3]
+ localRouterAddress[2] localRouterAddress[1] localRouterAddress[0]
+ destinationAddressIn[11] destinationAddressIn[10] destinationAddressIn[9]
+ destinationAddressIn[8] destinationAddressIn[7] destinationAddressIn[6]
+ destinationAddressIn[5] destinationAddressIn[4] destinationAddressIn[3]
+ destinationAddressIn[2] destinationAddressIn[1] destinationAddressIn[0]
+ requesterAddressIn[3] requesterAddressIn[2] requesterAddressIn[1]
+ requesterAddressIn[0] readIn writeIn outputPortSelect[3] outputPortSelect[2]
+ outputPortSelect[1] outputPortSelect[0] memRead memWrite
XmemRead_reg memRead clk n19 DFFQX1TS
XmemWrite_reg memWrite clk n27 DFFQX1TS
XoutputPortSelect_reg[3] outputPortSelect[3] clk n20 DFFHQX1TS
XoutputPortSelect_reg[1] outputPortSelect[1] clk n25 DFFHQX1TS
XoutputPortSelect_reg[2] outputPortSelect[2] clk n21 DFFQX1TS
XoutputPortSelect_reg[0] outputPortSelect[0] clk n26 DFFQX4TS
XU4 n27 n18 writeIn n17 memWrite AO22XLTS
XU5 n9 localRouterAddress[3] destinationAddressIn[11] NAND2BXLTS
XU6 n10 localRouterAddress[2] destinationAddressIn[10] NAND2BXLTS
XU7 n6 localRouterAddress[2] destinationAddressIn[10] NOR2BX1TS
XU8 n11 localRouterAddress[3] destinationAddressIn[11] NOR2BX1TS
XU9 n15 n9 n10 n6 n11 NOR4BBXLTS
XU10 n7 readIn writeIn reset AOI2BB1XLTS
XU11 n1 destinationAddressIn[9] INVX2TS
XU12 n2 destinationAddressIn[8] INVX2TS
XU13 n5 localRouterAddress[1] n1 localRouterAddress[0] n2 AOI22X1TS
XU14 n4 localRouterAddress[1] n1 OR2X1TS
XU15 n3 localRouterAddress[0] n2 OR2X1TS
XU16 n12 n5 n15 n4 n3 NAND4XLTS
XU17 n13 n5 n4 NAND2BXLTS
XU18 n21 n15 n7 n12 n13 AND4X1TS
XU19 n8 n9 n6 n11 AOI21X1TS
XU20 n14 n7 INVX2TS
XU21 n26 n8 n14 NOR2XLTS
XU22 n25 n14 n11 n10 n9 n14 OAI32X1TS
XU23 n18 reset n12 NOR2XLTS
XU24 n17 reset readIn writeIn NOR3XLTS
XU25 n19 readIn n18 memRead n17 AO22XLTS
XU26 n20 n15 n14 n13 NOR3BXLTS
.ENDS

.SUBCKT incomingPortHandler_3 clk reset localRouterAddress[3]
+ localRouterAddress[2] localRouterAddress[1] localRouterAddress[0]
+ destinationAddressIn[11] destinationAddressIn[10] destinationAddressIn[9]
+ destinationAddressIn[8] destinationAddressIn[7] destinationAddressIn[6]
+ destinationAddressIn[5] destinationAddressIn[4] destinationAddressIn[3]
+ destinationAddressIn[2] destinationAddressIn[1] destinationAddressIn[0]
+ requesterAddressIn[3] requesterAddressIn[2] requesterAddressIn[1]
+ requesterAddressIn[0] readIn writeIn outputPortSelect[3] outputPortSelect[2]
+ outputPortSelect[1] outputPortSelect[0] memRead memWrite
XoutputPortSelect_reg[3] outputPortSelect[3] clk n19 DFFHQX1TS
XoutputPortSelect_reg[1] outputPortSelect[1] clk n21 DFFHQX1TS
XoutputPortSelect_reg[0] outputPortSelect[0] clk n24 DFFHQX1TS
XmemWrite_reg memWrite clk n25 DFFQX1TS
XmemRead_reg memRead clk n18 DFFQX1TS
XoutputPortSelect_reg[2] outputPortSelect[2] clk n20 DFFQX1TS
XU3 n25 n17 writeIn n16 memWrite AO22XLTS
XU4 n9 localRouterAddress[3] destinationAddressIn[11] NAND2BXLTS
XU5 n10 localRouterAddress[2] destinationAddressIn[10] NAND2BXLTS
XU6 n6 localRouterAddress[2] destinationAddressIn[10] NOR2BX1TS
XU7 n11 localRouterAddress[3] destinationAddressIn[11] NOR2BX1TS
XU8 n15 n9 n10 n6 n11 NOR4BBXLTS
XU9 n7 readIn writeIn reset AOI2BB1XLTS
XU10 n1 destinationAddressIn[9] INVX2TS
XU11 n2 destinationAddressIn[8] INVX2TS
XU12 n5 localRouterAddress[1] n1 localRouterAddress[0] n2 AOI22X1TS
XU13 n4 localRouterAddress[1] n1 OR2X1TS
XU14 n3 localRouterAddress[0] n2 OR2X1TS
XU15 n12 n5 n15 n4 n3 NAND4XLTS
XU16 n13 n5 n4 NAND2BXLTS
XU17 n20 n15 n7 n12 n13 AND4X1TS
XU18 n8 n9 n6 n11 AOI21X1TS
XU19 n14 n7 INVX2TS
XU20 n24 n8 n14 NOR2XLTS
XU21 n21 n14 n11 n10 n9 n14 OAI32X1TS
XU22 n17 reset n12 NOR2XLTS
XU23 n16 reset readIn writeIn NOR3XLTS
XU24 n18 readIn n17 memRead n16 AO22XLTS
XU25 n19 n15 n14 n13 NOR3BXLTS
.ENDS

.SUBCKT router clk reset localRouterAddress[3] localRouterAddress[2]
+ localRouterAddress[1] localRouterAddress[0] destinationAddressIn_NORTH[11]
+ destinationAddressIn_NORTH[10] destinationAddressIn_NORTH[9]
+ destinationAddressIn_NORTH[8] destinationAddressIn_NORTH[7]
+ destinationAddressIn_NORTH[6] destinationAddressIn_NORTH[5]
+ destinationAddressIn_NORTH[4] destinationAddressIn_NORTH[3]
+ destinationAddressIn_NORTH[2] destinationAddressIn_NORTH[1]
+ destinationAddressIn_NORTH[0] requesterAddressIn_NORTH[3]
+ requesterAddressIn_NORTH[2] requesterAddressIn_NORTH[1]
+ requesterAddressIn_NORTH[0] readIn_NORTH writeIn_NORTH dataIn_NORTH[5]
+ dataIn_NORTH[4] dataIn_NORTH[3] dataIn_NORTH[2] dataIn_NORTH[1]
+ dataIn_NORTH[0] destinationAddressOut_NORTH[11]
+ destinationAddressOut_NORTH[10] destinationAddressOut_NORTH[9]
+ destinationAddressOut_NORTH[8] destinationAddressOut_NORTH[7]
+ destinationAddressOut_NORTH[6] destinationAddressOut_NORTH[5]
+ destinationAddressOut_NORTH[4] destinationAddressOut_NORTH[3]
+ destinationAddressOut_NORTH[2] destinationAddressOut_NORTH[1]
+ destinationAddressOut_NORTH[0] requesterAddressOut_NORTH[3]
+ requesterAddressOut_NORTH[2] requesterAddressOut_NORTH[1]
+ requesterAddressOut_NORTH[0] readOut_NORTH writeOut_NORTH dataOut_NORTH[5]
+ dataOut_NORTH[4] dataOut_NORTH[3] dataOut_NORTH[2] dataOut_NORTH[1]
+ dataOut_NORTH[0] destinationAddressIn_SOUTH[11]
+ destinationAddressIn_SOUTH[10] destinationAddressIn_SOUTH[9]
+ destinationAddressIn_SOUTH[8] destinationAddressIn_SOUTH[7]
+ destinationAddressIn_SOUTH[6] destinationAddressIn_SOUTH[5]
+ destinationAddressIn_SOUTH[4] destinationAddressIn_SOUTH[3]
+ destinationAddressIn_SOUTH[2] destinationAddressIn_SOUTH[1]
+ destinationAddressIn_SOUTH[0] requesterAddressIn_SOUTH[3]
+ requesterAddressIn_SOUTH[2] requesterAddressIn_SOUTH[1]
+ requesterAddressIn_SOUTH[0] readIn_SOUTH writeIn_SOUTH dataIn_SOUTH[5]
+ dataIn_SOUTH[4] dataIn_SOUTH[3] dataIn_SOUTH[2] dataIn_SOUTH[1]
+ dataIn_SOUTH[0] destinationAddressOut_SOUTH[11]
+ destinationAddressOut_SOUTH[10] destinationAddressOut_SOUTH[9]
+ destinationAddressOut_SOUTH[8] destinationAddressOut_SOUTH[7]
+ destinationAddressOut_SOUTH[6] destinationAddressOut_SOUTH[5]
+ destinationAddressOut_SOUTH[4] destinationAddressOut_SOUTH[3]
+ destinationAddressOut_SOUTH[2] destinationAddressOut_SOUTH[1]
+ destinationAddressOut_SOUTH[0] requesterAddressOut_SOUTH[3]
+ requesterAddressOut_SOUTH[2] requesterAddressOut_SOUTH[1]
+ requesterAddressOut_SOUTH[0] readOut_SOUTH writeOut_SOUTH dataOut_SOUTH[5]
+ dataOut_SOUTH[4] dataOut_SOUTH[3] dataOut_SOUTH[2] dataOut_SOUTH[1]
+ dataOut_SOUTH[0] destinationAddressIn_EAST[11] destinationAddressIn_EAST[10]
+ destinationAddressIn_EAST[9] destinationAddressIn_EAST[8]
+ destinationAddressIn_EAST[7] destinationAddressIn_EAST[6]
+ destinationAddressIn_EAST[5] destinationAddressIn_EAST[4]
+ destinationAddressIn_EAST[3] destinationAddressIn_EAST[2]
+ destinationAddressIn_EAST[1] destinationAddressIn_EAST[0]
+ requesterAddressIn_EAST[3] requesterAddressIn_EAST[2]
+ requesterAddressIn_EAST[1] requesterAddressIn_EAST[0] readIn_EAST
+ writeIn_EAST dataIn_EAST[5] dataIn_EAST[4] dataIn_EAST[3] dataIn_EAST[2]
+ dataIn_EAST[1] dataIn_EAST[0] destinationAddressOut_EAST[11]
+ destinationAddressOut_EAST[10] destinationAddressOut_EAST[9]
+ destinationAddressOut_EAST[8] destinationAddressOut_EAST[7]
+ destinationAddressOut_EAST[6] destinationAddressOut_EAST[5]
+ destinationAddressOut_EAST[4] destinationAddressOut_EAST[3]
+ destinationAddressOut_EAST[2] destinationAddressOut_EAST[1]
+ destinationAddressOut_EAST[0] requesterAddressOut_EAST[3]
+ requesterAddressOut_EAST[2] requesterAddressOut_EAST[1]
+ requesterAddressOut_EAST[0] readOut_EAST writeOut_EAST dataOut_EAST[5]
+ dataOut_EAST[4] dataOut_EAST[3] dataOut_EAST[2] dataOut_EAST[1]
+ dataOut_EAST[0] destinationAddressIn_WEST[11] destinationAddressIn_WEST[10]
+ destinationAddressIn_WEST[9] destinationAddressIn_WEST[8]
+ destinationAddressIn_WEST[7] destinationAddressIn_WEST[6]
+ destinationAddressIn_WEST[5] destinationAddressIn_WEST[4]
+ destinationAddressIn_WEST[3] destinationAddressIn_WEST[2]
+ destinationAddressIn_WEST[1] destinationAddressIn_WEST[0]
+ requesterAddressIn_WEST[3] requesterAddressIn_WEST[2]
+ requesterAddressIn_WEST[1] requesterAddressIn_WEST[0] readIn_WEST
+ writeIn_WEST dataIn_WEST[5] dataIn_WEST[4] dataIn_WEST[3] dataIn_WEST[2]
+ dataIn_WEST[1] dataIn_WEST[0] destinationAddressOut_WEST[11]
+ destinationAddressOut_WEST[10] destinationAddressOut_WEST[9]
+ destinationAddressOut_WEST[8] destinationAddressOut_WEST[7]
+ destinationAddressOut_WEST[6] destinationAddressOut_WEST[5]
+ destinationAddressOut_WEST[4] destinationAddressOut_WEST[3]
+ destinationAddressOut_WEST[2] destinationAddressOut_WEST[1]
+ destinationAddressOut_WEST[0] requesterAddressOut_WEST[3]
+ requesterAddressOut_WEST[2] requesterAddressOut_WEST[1]
+ requesterAddressOut_WEST[0] readOut_WEST writeOut_WEST dataOut_WEST[5]
+ dataOut_WEST[4] dataOut_WEST[3] dataOut_WEST[2] dataOut_WEST[1]
+ dataOut_WEST[0] cacheDataIn_A[5] cacheDataIn_A[4] cacheDataIn_A[3]
+ cacheDataIn_A[2] cacheDataIn_A[1] cacheDataIn_A[0] cacheAddressIn_A[7]
+ cacheAddressIn_A[6] cacheAddressIn_A[5] cacheAddressIn_A[4]
+ cacheAddressIn_A[3] cacheAddressIn_A[2] cacheAddressIn_A[1]
+ cacheAddressIn_A[0] cacheDataOut_A[5] cacheDataOut_A[4] cacheDataOut_A[3]
+ cacheDataOut_A[2] cacheDataOut_A[1] cacheDataOut_A[0] memWrite_A
+ portA_writtenTo cacheDataIn_B[5] cacheDataIn_B[4] cacheDataIn_B[3]
+ cacheDataIn_B[2] cacheDataIn_B[1] cacheDataIn_B[0] cacheAddressIn_B[7]
+ cacheAddressIn_B[6] cacheAddressIn_B[5] cacheAddressIn_B[4]
+ cacheAddressIn_B[3] cacheAddressIn_B[2] cacheAddressIn_B[1]
+ cacheAddressIn_B[0] cacheDataOut_B[5] cacheDataOut_B[4] cacheDataOut_B[3]
+ cacheDataOut_B[2] cacheDataOut_B[1] cacheDataOut_B[0] memWrite_B
+ portB_writtenTo
XFE_PHC270_cacheDataOut_B_1_ FE_PHN270_cacheDataOut_B_1_ cacheDataOut_B[1]
+ CLKBUFX2TS
XFE_PHC269_cacheDataOut_A_2_ FE_PHN269_cacheDataOut_A_2_ cacheDataOut_A[2]
+ DLY2X1TS
XFE_PHC268_cacheDataOut_B_2_ FE_PHN268_cacheDataOut_B_2_ cacheDataOut_B[2]
+ DLY2X1TS
XFE_PHC267_reset FE_PHN267_reset reset DLY2X1TS
XFE_PHC264_cacheDataOut_A_1_ FE_PHN264_cacheDataOut_A_1_ cacheDataOut_A[1]
+ DLY2X1TS
XFE_PHC263_cacheDataOut_B_1_ FE_PHN263_cacheDataOut_B_1_
+ FE_PHN270_cacheDataOut_B_1_ CLKBUFX2TS
XFE_PHC262_cacheDataOut_A_4_ FE_PHN262_cacheDataOut_A_4_ cacheDataOut_A[4]
+ DLY2X1TS
XFE_PHC261_cacheDataOut_B_3_ FE_PHN261_cacheDataOut_B_3_ cacheDataOut_B[3]
+ DLY1X1TS
XFE_PHC260_cacheDataOut_B_4_ FE_PHN260_cacheDataOut_B_4_ cacheDataOut_B[4]
+ DLY2X1TS
XFE_PHC259_cacheDataOut_A_5_ FE_PHN259_cacheDataOut_A_5_ cacheDataOut_A[5]
+ DLY2X1TS
XFE_PHC258_cacheDataOut_B_5_ FE_PHN258_cacheDataOut_B_5_ cacheDataOut_B[5]
+ DLY2X1TS
XFE_PHC257_cacheDataOut_A_3_ FE_PHN257_cacheDataOut_A_3_ cacheDataOut_A[3]
+ DLY3X1TS
XFE_PHC256_reset FE_PHN256_reset FE_PHN267_reset CLKBUFX2TS
XFE_PHC255_cacheDataOut_B_2_ FE_PHN255_cacheDataOut_B_2_
+ FE_PHN268_cacheDataOut_B_2_ CLKBUFX2TS
XFE_PHC254_cacheDataOut_B_3_ FE_PHN254_cacheDataOut_B_3_
+ FE_PHN261_cacheDataOut_B_3_ CLKBUFX2TS
XFE_PHC253_cacheDataOut_A_3_ FE_PHN253_cacheDataOut_A_3_
+ FE_PHN257_cacheDataOut_A_3_ CLKBUFX2TS
XFE_PHC252_cacheDataOut_B_5_ FE_PHN252_cacheDataOut_B_5_
+ FE_PHN258_cacheDataOut_B_5_ CLKBUFX2TS
XFE_PHC251_cacheDataOut_B_1_ FE_PHN251_cacheDataOut_B_1_
+ FE_PHN263_cacheDataOut_B_1_ CLKBUFX2TS
XFE_PHC250_cacheDataOut_B_4_ FE_PHN250_cacheDataOut_B_4_
+ FE_PHN260_cacheDataOut_B_4_ CLKBUFX2TS
XFE_PHC249_cacheDataOut_A_2_ FE_PHN249_cacheDataOut_A_2_
+ FE_PHN269_cacheDataOut_A_2_ CLKBUFX2TS
XFE_PHC248_cacheDataOut_A_5_ FE_PHN248_cacheDataOut_A_5_
+ FE_PHN259_cacheDataOut_A_5_ CLKBUFX2TS
XFE_PHC247_cacheDataOut_A_1_ FE_PHN247_cacheDataOut_A_1_
+ FE_PHN264_cacheDataOut_A_1_ CLKBUFX2TS
XFE_PHC246_cacheDataOut_B_0_ FE_PHN246_cacheDataOut_B_0_ cacheDataOut_B[0]
+ DLY3X4TS
XFE_PHC245_cacheDataOut_A_4_ FE_PHN245_cacheDataOut_A_4_
+ FE_PHN262_cacheDataOut_A_4_ CLKBUFX2TS
XFE_PHC244_cacheDataOut_A_0_ FE_PHN244_cacheDataOut_A_0_ cacheDataOut_A[0]
+ DLY3X4TS
XFE_PHC231_reset FE_PHN231_reset FE_PHN256_reset CLKBUFX16TS
Xclk__L1_I0 clk__L1_N0 clk CLKINVX16TS
XinNorth clk__L1_N0 FE_PHN231_reset localRouterAddress[3] localRouterAddress[2]
+ localRouterAddress[1] localRouterAddress[0] destinationAddressIn_NORTH[11]
+ destinationAddressIn_NORTH[10] destinationAddressIn_NORTH[9]
+ destinationAddressIn_NORTH[8] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+ readInBuffer_NORTH writeInBuffer_NORTH outputPortSelect_NORTH[3]
+ outputPortSelect_NORTH[2] outputPortSelect_NORTH[1] outputPortSelect_NORTH[0]
+ memRead_NORTH memWrite_NORTH incomingPortHandler_0
XinSouth clk__L1_N0 FE_PHN231_reset localRouterAddress[3] localRouterAddress[2]
+ localRouterAddress[1] localRouterAddress[0] destinationAddressIn_SOUTH[11]
+ destinationAddressIn_SOUTH[10] destinationAddressIn_SOUTH[9]
+ destinationAddressIn_SOUTH[8] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+ readInBuffer_SOUTH writeInBuffer_SOUTH outputPortSelect_SOUTH[3]
+ outputPortSelect_SOUTH[2] outputPortSelect_SOUTH[1] outputPortSelect_SOUTH[0]
+ memRead_SOUTH memWrite_SOUTH incomingPortHandler_3
XinEast clk__L1_N0 FE_PHN231_reset localRouterAddress[3] localRouterAddress[2]
+ localRouterAddress[1] localRouterAddress[0] destinationAddressIn_EAST[11]
+ destinationAddressIn_EAST[10] destinationAddressIn_EAST[9]
+ destinationAddressIn_EAST[8] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+ readInBuffer_EAST writeInBuffer_EAST outputPortSelect_EAST[3]
+ outputPortSelect_EAST[2] outputPortSelect_EAST[1] outputPortSelect_EAST[0]
+ memRead_EAST n1 incomingPortHandler_2
XinWest clk__L1_N0 FE_PHN231_reset localRouterAddress[3] localRouterAddress[2]
+ localRouterAddress[1] localRouterAddress[0] destinationAddressIn_WEST[11]
+ destinationAddressIn_WEST[10] destinationAddressIn_WEST[9]
+ destinationAddressIn_WEST[8] VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+ readInBuffer_WEST writeInBuffer_WEST outputPortSelect_WEST[3]
+ outputPortSelect_WEST[2] outputPortSelect_WEST[1] outputPortSelect_WEST[0]
+ memRead_WEST n2 incomingPortHandler_1
XcacheController clk__L1_N0 FE_PHN231_reset destinationAddressInBuffer_NORTH[7]
+ destinationAddressInBuffer_NORTH[6] destinationAddressInBuffer_NORTH[5]
+ destinationAddressInBuffer_NORTH[4] destinationAddressInBuffer_NORTH[3]
+ destinationAddressInBuffer_NORTH[2] destinationAddressInBuffer_NORTH[1]
+ destinationAddressInBuffer_NORTH[0] requesterAddressInBuffer_NORTH[3]
+ requesterAddressInBuffer_NORTH[2] requesterAddressInBuffer_NORTH[1]
+ requesterAddressInBuffer_NORTH[0] memRead_NORTH memWrite_NORTH
+ dataInBuffer_NORTH[5] dataInBuffer_NORTH[4] dataInBuffer_NORTH[3]
+ dataInBuffer_NORTH[2] dataInBuffer_NORTH[1] dataInBuffer_NORTH[0]
+ readReady_NORTH cacheRequesterAddress_NORTH[3] cacheRequesterAddress_NORTH[2]
+ cacheRequesterAddress_NORTH[1] cacheRequesterAddress_NORTH[0]
+ cacheDataOut_NORTH[5] cacheDataOut_NORTH[4] cacheDataOut_NORTH[3]
+ cacheDataOut_NORTH[2] cacheDataOut_NORTH[1] cacheDataOut_NORTH[0]
+ destinationAddressInBuffer_SOUTH[7] destinationAddressInBuffer_SOUTH[6]
+ destinationAddressInBuffer_SOUTH[5] destinationAddressInBuffer_SOUTH[4]
+ destinationAddressInBuffer_SOUTH[3] destinationAddressInBuffer_SOUTH[2]
+ destinationAddressInBuffer_SOUTH[1] destinationAddressInBuffer_SOUTH[0]
+ requesterAddressInBuffer_SOUTH[3] requesterAddressInBuffer_SOUTH[2]
+ requesterAddressInBuffer_SOUTH[1] requesterAddressInBuffer_SOUTH[0]
+ memRead_SOUTH memWrite_SOUTH dataInBuffer_SOUTH[5] dataInBuffer_SOUTH[4]
+ dataInBuffer_SOUTH[3] dataInBuffer_SOUTH[2] dataInBuffer_SOUTH[1]
+ dataInBuffer_SOUTH[0] readReady_SOUTH cacheRequesterAddress_SOUTH[3]
+ cacheRequesterAddress_SOUTH[2] cacheRequesterAddress_SOUTH[1]
+ cacheRequesterAddress_SOUTH[0] cacheDataOut_SOUTH[5] cacheDataOut_SOUTH[4]
+ cacheDataOut_SOUTH[3] cacheDataOut_SOUTH[2] cacheDataOut_SOUTH[1]
+ cacheDataOut_SOUTH[0] destinationAddressInBuffer_EAST[7]
+ destinationAddressInBuffer_EAST[6] destinationAddressInBuffer_EAST[5]
+ destinationAddressInBuffer_EAST[4] destinationAddressInBuffer_EAST[3]
+ destinationAddressInBuffer_EAST[2] destinationAddressInBuffer_EAST[1]
+ destinationAddressInBuffer_EAST[0] requesterAddressInBuffer_EAST[3]
+ requesterAddressInBuffer_EAST[2] requesterAddressInBuffer_EAST[1]
+ requesterAddressInBuffer_EAST[0] memRead_EAST n1 dataInBuffer_EAST[5]
+ dataInBuffer_EAST[4] dataInBuffer_EAST[3] dataInBuffer_EAST[2]
+ dataInBuffer_EAST[1] dataInBuffer_EAST[0] readReady_EAST
+ cacheRequesterAddress_EAST[3] cacheRequesterAddress_EAST[2]
+ cacheRequesterAddress_EAST[1] cacheRequesterAddress_EAST[0]
+ cacheDataOut_EAST[5] cacheDataOut_EAST[4] cacheDataOut_EAST[3]
+ cacheDataOut_EAST[2] cacheDataOut_EAST[1] cacheDataOut_EAST[0]
+ destinationAddressInBuffer_WEST[7] destinationAddressInBuffer_WEST[6]
+ destinationAddressInBuffer_WEST[5] destinationAddressInBuffer_WEST[4]
+ destinationAddressInBuffer_WEST[3] destinationAddressInBuffer_WEST[2]
+ destinationAddressInBuffer_WEST[1] destinationAddressInBuffer_WEST[0]
+ requesterAddressInBuffer_WEST[3] requesterAddressInBuffer_WEST[2]
+ requesterAddressInBuffer_WEST[1] requesterAddressInBuffer_WEST[0]
+ memRead_WEST n2 dataInBuffer_WEST[5] dataInBuffer_WEST[4]
+ dataInBuffer_WEST[3] dataInBuffer_WEST[2] dataInBuffer_WEST[1]
+ dataInBuffer_WEST[0] readReady_WEST cacheRequesterAddress_WEST[3]
+ cacheRequesterAddress_WEST[2] cacheRequesterAddress_WEST[1]
+ cacheRequesterAddress_WEST[0] cacheDataOut_WEST[5] cacheDataOut_WEST[4]
+ cacheDataOut_WEST[3] cacheDataOut_WEST[2] cacheDataOut_WEST[1]
+ cacheDataOut_WEST[0] cacheDataIn_A[5] cacheDataIn_A[4] cacheDataIn_A[3]
+ cacheDataIn_A[2] cacheDataIn_A[1] cacheDataIn_A[0] cacheAddressIn_A[7]
+ cacheAddressIn_A[6] cacheAddressIn_A[5] cacheAddressIn_A[4]
+ cacheAddressIn_A[3] cacheAddressIn_A[2] cacheAddressIn_A[1]
+ cacheAddressIn_A[0] FE_PHN248_cacheDataOut_A_5_ FE_PHN245_cacheDataOut_A_4_
+ FE_PHN253_cacheDataOut_A_3_ FE_PHN249_cacheDataOut_A_2_
+ FE_PHN247_cacheDataOut_A_1_ FE_PHN244_cacheDataOut_A_0_ memWrite_A
+ cacheDataIn_B[5] cacheDataIn_B[4] cacheDataIn_B[3] cacheDataIn_B[2]
+ cacheDataIn_B[1] cacheDataIn_B[0] cacheAddressIn_B[7] cacheAddressIn_B[6]
+ cacheAddressIn_B[5] cacheAddressIn_B[4] cacheAddressIn_B[3]
+ cacheAddressIn_B[2] cacheAddressIn_B[1] cacheAddressIn_B[0]
+ FE_PHN252_cacheDataOut_B_5_ FE_PHN250_cacheDataOut_B_4_
+ FE_PHN254_cacheDataOut_B_3_ FE_PHN255_cacheDataOut_B_2_
+ FE_PHN251_cacheDataOut_B_1_ FE_PHN246_cacheDataOut_B_0_ memWrite_B
+ cacheAccessArbiter
XoutNorth clk__L1_N0 FE_PHN231_reset outputPortSelect_NORTH[0]
+ destinationAddressInBuffer_NORTH[11] destinationAddressInBuffer_NORTH[10]
+ destinationAddressInBuffer_NORTH[9] destinationAddressInBuffer_NORTH[8]
+ destinationAddressInBuffer_NORTH[7] destinationAddressInBuffer_NORTH[6]
+ destinationAddressInBuffer_NORTH[5] destinationAddressInBuffer_NORTH[4]
+ destinationAddressInBuffer_NORTH[3] destinationAddressInBuffer_NORTH[2]
+ destinationAddressInBuffer_NORTH[1] destinationAddressInBuffer_NORTH[0]
+ requesterAddressInBuffer_NORTH[3] requesterAddressInBuffer_NORTH[2]
+ requesterAddressInBuffer_NORTH[1] requesterAddressInBuffer_NORTH[0]
+ readInBuffer_NORTH writeInBuffer_NORTH dataInBuffer_NORTH[5]
+ dataInBuffer_NORTH[4] dataInBuffer_NORTH[3] dataInBuffer_NORTH[2]
+ dataInBuffer_NORTH[1] dataInBuffer_NORTH[0] outputPortSelect_SOUTH[0]
+ destinationAddressInBuffer_SOUTH[11] destinationAddressInBuffer_SOUTH[10]
+ destinationAddressInBuffer_SOUTH[9] destinationAddressInBuffer_SOUTH[8]
+ destinationAddressInBuffer_SOUTH[7] destinationAddressInBuffer_SOUTH[6]
+ destinationAddressInBuffer_SOUTH[5] destinationAddressInBuffer_SOUTH[4]
+ destinationAddressInBuffer_SOUTH[3] destinationAddressInBuffer_SOUTH[2]
+ destinationAddressInBuffer_SOUTH[1] destinationAddressInBuffer_SOUTH[0]
+ requesterAddressInBuffer_SOUTH[3] requesterAddressInBuffer_SOUTH[2]
+ requesterAddressInBuffer_SOUTH[1] requesterAddressInBuffer_SOUTH[0]
+ readInBuffer_SOUTH writeInBuffer_SOUTH dataInBuffer_SOUTH[5]
+ dataInBuffer_SOUTH[4] dataInBuffer_SOUTH[3] dataInBuffer_SOUTH[2]
+ dataInBuffer_SOUTH[1] dataInBuffer_SOUTH[0] outputPortSelect_EAST[0]
+ destinationAddressInBuffer_EAST[11] destinationAddressInBuffer_EAST[10]
+ destinationAddressInBuffer_EAST[9] destinationAddressInBuffer_EAST[8]
+ destinationAddressInBuffer_EAST[7] destinationAddressInBuffer_EAST[6]
+ destinationAddressInBuffer_EAST[5] destinationAddressInBuffer_EAST[4]
+ destinationAddressInBuffer_EAST[3] destinationAddressInBuffer_EAST[2]
+ destinationAddressInBuffer_EAST[1] destinationAddressInBuffer_EAST[0]
+ requesterAddressInBuffer_EAST[3] requesterAddressInBuffer_EAST[2]
+ requesterAddressInBuffer_EAST[1] requesterAddressInBuffer_EAST[0]
+ readInBuffer_EAST writeInBuffer_EAST dataInBuffer_EAST[5]
+ dataInBuffer_EAST[4] dataInBuffer_EAST[3] dataInBuffer_EAST[2]
+ dataInBuffer_EAST[1] dataInBuffer_EAST[0] outputPortSelect_WEST[0]
+ destinationAddressInBuffer_WEST[11] destinationAddressInBuffer_WEST[10]
+ destinationAddressInBuffer_WEST[9] destinationAddressInBuffer_WEST[8]
+ destinationAddressInBuffer_WEST[7] destinationAddressInBuffer_WEST[6]
+ destinationAddressInBuffer_WEST[5] destinationAddressInBuffer_WEST[4]
+ destinationAddressInBuffer_WEST[3] destinationAddressInBuffer_WEST[2]
+ destinationAddressInBuffer_WEST[1] destinationAddressInBuffer_WEST[0]
+ requesterAddressInBuffer_WEST[3] requesterAddressInBuffer_WEST[2]
+ requesterAddressInBuffer_WEST[1] requesterAddressInBuffer_WEST[0]
+ readInBuffer_WEST writeInBuffer_WEST dataInBuffer_WEST[5]
+ dataInBuffer_WEST[4] dataInBuffer_WEST[3] dataInBuffer_WEST[2]
+ dataInBuffer_WEST[1] dataInBuffer_WEST[0] readReady_NORTH
+ cacheRequesterAddress_NORTH[3] cacheRequesterAddress_NORTH[2]
+ cacheRequesterAddress_NORTH[1] cacheRequesterAddress_NORTH[0]
+ cacheDataOut_NORTH[5] cacheDataOut_NORTH[4] cacheDataOut_NORTH[3]
+ cacheDataOut_NORTH[2] cacheDataOut_NORTH[1] cacheDataOut_NORTH[0]
+ destinationAddressOut_NORTH[11] destinationAddressOut_NORTH[10]
+ destinationAddressOut_NORTH[9] destinationAddressOut_NORTH[8]
+ destinationAddressOut_NORTH[7] destinationAddressOut_NORTH[6]
+ destinationAddressOut_NORTH[5] destinationAddressOut_NORTH[4]
+ destinationAddressOut_NORTH[3] destinationAddressOut_NORTH[2]
+ destinationAddressOut_NORTH[1] destinationAddressOut_NORTH[0]
+ requesterAddressOut_NORTH[3] requesterAddressOut_NORTH[2]
+ requesterAddressOut_NORTH[1] requesterAddressOut_NORTH[0] readOut_NORTH
+ writeOut_NORTH dataOut_NORTH[5] dataOut_NORTH[4] dataOut_NORTH[3]
+ dataOut_NORTH[2] dataOut_NORTH[1] dataOut_NORTH[0] outputPortArbiter_0
XoutSouth clk__L1_N0 FE_PHN231_reset outputPortSelect_NORTH[1]
+ destinationAddressInBuffer_NORTH[11] destinationAddressInBuffer_NORTH[10]
+ destinationAddressInBuffer_NORTH[9] destinationAddressInBuffer_NORTH[8]
+ destinationAddressInBuffer_NORTH[7] destinationAddressInBuffer_NORTH[6]
+ destinationAddressInBuffer_NORTH[5] destinationAddressInBuffer_NORTH[4]
+ destinationAddressInBuffer_NORTH[3] destinationAddressInBuffer_NORTH[2]
+ destinationAddressInBuffer_NORTH[1] destinationAddressInBuffer_NORTH[0]
+ requesterAddressInBuffer_NORTH[3] requesterAddressInBuffer_NORTH[2]
+ requesterAddressInBuffer_NORTH[1] requesterAddressInBuffer_NORTH[0]
+ readInBuffer_NORTH writeInBuffer_NORTH dataInBuffer_NORTH[5]
+ dataInBuffer_NORTH[4] dataInBuffer_NORTH[3] dataInBuffer_NORTH[2]
+ dataInBuffer_NORTH[1] dataInBuffer_NORTH[0] outputPortSelect_SOUTH[1]
+ destinationAddressInBuffer_SOUTH[11] destinationAddressInBuffer_SOUTH[10]
+ destinationAddressInBuffer_SOUTH[9] destinationAddressInBuffer_SOUTH[8]
+ destinationAddressInBuffer_SOUTH[7] destinationAddressInBuffer_SOUTH[6]
+ destinationAddressInBuffer_SOUTH[5] destinationAddressInBuffer_SOUTH[4]
+ destinationAddressInBuffer_SOUTH[3] destinationAddressInBuffer_SOUTH[2]
+ destinationAddressInBuffer_SOUTH[1] destinationAddressInBuffer_SOUTH[0]
+ requesterAddressInBuffer_SOUTH[3] requesterAddressInBuffer_SOUTH[2]
+ requesterAddressInBuffer_SOUTH[1] requesterAddressInBuffer_SOUTH[0]
+ readInBuffer_SOUTH writeInBuffer_SOUTH dataInBuffer_SOUTH[5]
+ dataInBuffer_SOUTH[4] dataInBuffer_SOUTH[3] dataInBuffer_SOUTH[2]
+ dataInBuffer_SOUTH[1] dataInBuffer_SOUTH[0] outputPortSelect_EAST[1]
+ destinationAddressInBuffer_EAST[11] destinationAddressInBuffer_EAST[10]
+ destinationAddressInBuffer_EAST[9] destinationAddressInBuffer_EAST[8]
+ destinationAddressInBuffer_EAST[7] destinationAddressInBuffer_EAST[6]
+ destinationAddressInBuffer_EAST[5] destinationAddressInBuffer_EAST[4]
+ destinationAddressInBuffer_EAST[3] destinationAddressInBuffer_EAST[2]
+ destinationAddressInBuffer_EAST[1] destinationAddressInBuffer_EAST[0]
+ requesterAddressInBuffer_EAST[3] requesterAddressInBuffer_EAST[2]
+ requesterAddressInBuffer_EAST[1] requesterAddressInBuffer_EAST[0]
+ readInBuffer_EAST writeInBuffer_EAST dataInBuffer_EAST[5]
+ dataInBuffer_EAST[4] dataInBuffer_EAST[3] dataInBuffer_EAST[2]
+ dataInBuffer_EAST[1] dataInBuffer_EAST[0] outputPortSelect_WEST[1]
+ destinationAddressInBuffer_WEST[11] destinationAddressInBuffer_WEST[10]
+ destinationAddressInBuffer_WEST[9] destinationAddressInBuffer_WEST[8]
+ destinationAddressInBuffer_WEST[7] destinationAddressInBuffer_WEST[6]
+ destinationAddressInBuffer_WEST[5] destinationAddressInBuffer_WEST[4]
+ destinationAddressInBuffer_WEST[3] destinationAddressInBuffer_WEST[2]
+ destinationAddressInBuffer_WEST[1] destinationAddressInBuffer_WEST[0]
+ requesterAddressInBuffer_WEST[3] requesterAddressInBuffer_WEST[2]
+ requesterAddressInBuffer_WEST[1] requesterAddressInBuffer_WEST[0]
+ readInBuffer_WEST writeInBuffer_WEST dataInBuffer_WEST[5]
+ dataInBuffer_WEST[4] dataInBuffer_WEST[3] dataInBuffer_WEST[2]
+ dataInBuffer_WEST[1] dataInBuffer_WEST[0] readReady_SOUTH
+ cacheRequesterAddress_SOUTH[3] cacheRequesterAddress_SOUTH[2]
+ cacheRequesterAddress_SOUTH[1] cacheRequesterAddress_SOUTH[0]
+ cacheDataOut_SOUTH[5] cacheDataOut_SOUTH[4] cacheDataOut_SOUTH[3]
+ cacheDataOut_SOUTH[2] cacheDataOut_SOUTH[1] cacheDataOut_SOUTH[0]
+ destinationAddressOut_SOUTH[11] destinationAddressOut_SOUTH[10]
+ destinationAddressOut_SOUTH[9] destinationAddressOut_SOUTH[8]
+ destinationAddressOut_SOUTH[7] destinationAddressOut_SOUTH[6]
+ destinationAddressOut_SOUTH[5] destinationAddressOut_SOUTH[4]
+ destinationAddressOut_SOUTH[3] destinationAddressOut_SOUTH[2]
+ destinationAddressOut_SOUTH[1] destinationAddressOut_SOUTH[0]
+ requesterAddressOut_SOUTH[3] requesterAddressOut_SOUTH[2]
+ requesterAddressOut_SOUTH[1] requesterAddressOut_SOUTH[0] readOut_SOUTH
+ writeOut_SOUTH dataOut_SOUTH[5] dataOut_SOUTH[4] dataOut_SOUTH[3]
+ dataOut_SOUTH[2] dataOut_SOUTH[1] dataOut_SOUTH[0] outputPortArbiter_3
XoutEast clk__L1_N0 FE_PHN231_reset outputPortSelect_NORTH[2]
+ destinationAddressInBuffer_NORTH[11] destinationAddressInBuffer_NORTH[10]
+ destinationAddressInBuffer_NORTH[9] destinationAddressInBuffer_NORTH[8]
+ destinationAddressInBuffer_NORTH[7] destinationAddressInBuffer_NORTH[6]
+ destinationAddressInBuffer_NORTH[5] destinationAddressInBuffer_NORTH[4]
+ destinationAddressInBuffer_NORTH[3] destinationAddressInBuffer_NORTH[2]
+ destinationAddressInBuffer_NORTH[1] destinationAddressInBuffer_NORTH[0]
+ requesterAddressInBuffer_NORTH[3] requesterAddressInBuffer_NORTH[2]
+ requesterAddressInBuffer_NORTH[1] requesterAddressInBuffer_NORTH[0]
+ readInBuffer_NORTH writeInBuffer_NORTH dataInBuffer_NORTH[5]
+ dataInBuffer_NORTH[4] dataInBuffer_NORTH[3] dataInBuffer_NORTH[2]
+ dataInBuffer_NORTH[1] dataInBuffer_NORTH[0] outputPortSelect_SOUTH[2]
+ destinationAddressInBuffer_SOUTH[11] destinationAddressInBuffer_SOUTH[10]
+ destinationAddressInBuffer_SOUTH[9] destinationAddressInBuffer_SOUTH[8]
+ destinationAddressInBuffer_SOUTH[7] destinationAddressInBuffer_SOUTH[6]
+ destinationAddressInBuffer_SOUTH[5] destinationAddressInBuffer_SOUTH[4]
+ destinationAddressInBuffer_SOUTH[3] destinationAddressInBuffer_SOUTH[2]
+ destinationAddressInBuffer_SOUTH[1] destinationAddressInBuffer_SOUTH[0]
+ requesterAddressInBuffer_SOUTH[3] requesterAddressInBuffer_SOUTH[2]
+ requesterAddressInBuffer_SOUTH[1] requesterAddressInBuffer_SOUTH[0]
+ readInBuffer_SOUTH writeInBuffer_SOUTH dataInBuffer_SOUTH[5]
+ dataInBuffer_SOUTH[4] dataInBuffer_SOUTH[3] dataInBuffer_SOUTH[2]
+ dataInBuffer_SOUTH[1] dataInBuffer_SOUTH[0] outputPortSelect_EAST[2]
+ destinationAddressInBuffer_EAST[11] destinationAddressInBuffer_EAST[10]
+ destinationAddressInBuffer_EAST[9] destinationAddressInBuffer_EAST[8]
+ destinationAddressInBuffer_EAST[7] destinationAddressInBuffer_EAST[6]
+ destinationAddressInBuffer_EAST[5] destinationAddressInBuffer_EAST[4]
+ destinationAddressInBuffer_EAST[3] destinationAddressInBuffer_EAST[2]
+ destinationAddressInBuffer_EAST[1] destinationAddressInBuffer_EAST[0]
+ requesterAddressInBuffer_EAST[3] requesterAddressInBuffer_EAST[2]
+ requesterAddressInBuffer_EAST[1] requesterAddressInBuffer_EAST[0]
+ readInBuffer_EAST writeInBuffer_EAST dataInBuffer_EAST[5]
+ dataInBuffer_EAST[4] dataInBuffer_EAST[3] dataInBuffer_EAST[2]
+ dataInBuffer_EAST[1] dataInBuffer_EAST[0] outputPortSelect_WEST[2]
+ destinationAddressInBuffer_WEST[11] destinationAddressInBuffer_WEST[10]
+ destinationAddressInBuffer_WEST[9] destinationAddressInBuffer_WEST[8]
+ destinationAddressInBuffer_WEST[7] destinationAddressInBuffer_WEST[6]
+ destinationAddressInBuffer_WEST[5] destinationAddressInBuffer_WEST[4]
+ destinationAddressInBuffer_WEST[3] destinationAddressInBuffer_WEST[2]
+ destinationAddressInBuffer_WEST[1] destinationAddressInBuffer_WEST[0]
+ requesterAddressInBuffer_WEST[3] requesterAddressInBuffer_WEST[2]
+ requesterAddressInBuffer_WEST[1] requesterAddressInBuffer_WEST[0]
+ readInBuffer_WEST writeInBuffer_WEST dataInBuffer_WEST[5]
+ dataInBuffer_WEST[4] dataInBuffer_WEST[3] dataInBuffer_WEST[2]
+ dataInBuffer_WEST[1] dataInBuffer_WEST[0] readReady_EAST
+ cacheRequesterAddress_EAST[3] cacheRequesterAddress_EAST[2]
+ cacheRequesterAddress_EAST[1] cacheRequesterAddress_EAST[0]
+ cacheDataOut_EAST[5] cacheDataOut_EAST[4] cacheDataOut_EAST[3]
+ cacheDataOut_EAST[2] cacheDataOut_EAST[1] cacheDataOut_EAST[0]
+ destinationAddressOut_EAST[11] destinationAddressOut_EAST[10]
+ destinationAddressOut_EAST[9] destinationAddressOut_EAST[8]
+ destinationAddressOut_EAST[7] destinationAddressOut_EAST[6]
+ destinationAddressOut_EAST[5] destinationAddressOut_EAST[4]
+ destinationAddressOut_EAST[3] destinationAddressOut_EAST[2]
+ destinationAddressOut_EAST[1] destinationAddressOut_EAST[0]
+ requesterAddressOut_EAST[3] requesterAddressOut_EAST[2]
+ requesterAddressOut_EAST[1] requesterAddressOut_EAST[0] readOut_EAST
+ writeOut_EAST dataOut_EAST[5] dataOut_EAST[4] dataOut_EAST[3] dataOut_EAST[2]
+ dataOut_EAST[1] dataOut_EAST[0] outputPortArbiter_2
XoutWest clk__L1_N0 FE_PHN231_reset outputPortSelect_NORTH[3]
+ destinationAddressInBuffer_NORTH[11] destinationAddressInBuffer_NORTH[10]
+ destinationAddressInBuffer_NORTH[9] destinationAddressInBuffer_NORTH[8]
+ destinationAddressInBuffer_NORTH[7] destinationAddressInBuffer_NORTH[6]
+ destinationAddressInBuffer_NORTH[5] destinationAddressInBuffer_NORTH[4]
+ destinationAddressInBuffer_NORTH[3] destinationAddressInBuffer_NORTH[2]
+ destinationAddressInBuffer_NORTH[1] destinationAddressInBuffer_NORTH[0]
+ requesterAddressInBuffer_NORTH[3] requesterAddressInBuffer_NORTH[2]
+ requesterAddressInBuffer_NORTH[1] requesterAddressInBuffer_NORTH[0]
+ readInBuffer_NORTH writeInBuffer_NORTH dataInBuffer_NORTH[5]
+ dataInBuffer_NORTH[4] dataInBuffer_NORTH[3] dataInBuffer_NORTH[2]
+ dataInBuffer_NORTH[1] dataInBuffer_NORTH[0] outputPortSelect_SOUTH[3]
+ destinationAddressInBuffer_SOUTH[11] destinationAddressInBuffer_SOUTH[10]
+ destinationAddressInBuffer_SOUTH[9] destinationAddressInBuffer_SOUTH[8]
+ destinationAddressInBuffer_SOUTH[7] destinationAddressInBuffer_SOUTH[6]
+ destinationAddressInBuffer_SOUTH[5] destinationAddressInBuffer_SOUTH[4]
+ destinationAddressInBuffer_SOUTH[3] destinationAddressInBuffer_SOUTH[2]
+ destinationAddressInBuffer_SOUTH[1] destinationAddressInBuffer_SOUTH[0]
+ requesterAddressInBuffer_SOUTH[3] requesterAddressInBuffer_SOUTH[2]
+ requesterAddressInBuffer_SOUTH[1] requesterAddressInBuffer_SOUTH[0]
+ readInBuffer_SOUTH writeInBuffer_SOUTH dataInBuffer_SOUTH[5]
+ dataInBuffer_SOUTH[4] dataInBuffer_SOUTH[3] dataInBuffer_SOUTH[2]
+ dataInBuffer_SOUTH[1] dataInBuffer_SOUTH[0] outputPortSelect_EAST[3]
+ destinationAddressInBuffer_EAST[11] destinationAddressInBuffer_EAST[10]
+ destinationAddressInBuffer_EAST[9] destinationAddressInBuffer_EAST[8]
+ destinationAddressInBuffer_EAST[7] destinationAddressInBuffer_EAST[6]
+ destinationAddressInBuffer_EAST[5] destinationAddressInBuffer_EAST[4]
+ destinationAddressInBuffer_EAST[3] destinationAddressInBuffer_EAST[2]
+ destinationAddressInBuffer_EAST[1] destinationAddressInBuffer_EAST[0]
+ requesterAddressInBuffer_EAST[3] requesterAddressInBuffer_EAST[2]
+ requesterAddressInBuffer_EAST[1] requesterAddressInBuffer_EAST[0]
+ readInBuffer_EAST writeInBuffer_EAST dataInBuffer_EAST[5]
+ dataInBuffer_EAST[4] dataInBuffer_EAST[3] dataInBuffer_EAST[2]
+ dataInBuffer_EAST[1] dataInBuffer_EAST[0] outputPortSelect_WEST[3]
+ destinationAddressInBuffer_WEST[11] destinationAddressInBuffer_WEST[10]
+ destinationAddressInBuffer_WEST[9] destinationAddressInBuffer_WEST[8]
+ destinationAddressInBuffer_WEST[7] destinationAddressInBuffer_WEST[6]
+ destinationAddressInBuffer_WEST[5] destinationAddressInBuffer_WEST[4]
+ destinationAddressInBuffer_WEST[3] destinationAddressInBuffer_WEST[2]
+ destinationAddressInBuffer_WEST[1] destinationAddressInBuffer_WEST[0]
+ requesterAddressInBuffer_WEST[3] requesterAddressInBuffer_WEST[2]
+ requesterAddressInBuffer_WEST[1] requesterAddressInBuffer_WEST[0]
+ readInBuffer_WEST writeInBuffer_WEST dataInBuffer_WEST[5]
+ dataInBuffer_WEST[4] dataInBuffer_WEST[3] dataInBuffer_WEST[2]
+ dataInBuffer_WEST[1] dataInBuffer_WEST[0] readReady_WEST
+ cacheRequesterAddress_WEST[3] cacheRequesterAddress_WEST[2]
+ cacheRequesterAddress_WEST[1] cacheRequesterAddress_WEST[0]
+ cacheDataOut_WEST[5] cacheDataOut_WEST[4] cacheDataOut_WEST[3]
+ cacheDataOut_WEST[2] cacheDataOut_WEST[1] cacheDataOut_WEST[0]
+ destinationAddressOut_WEST[11] destinationAddressOut_WEST[10]
+ destinationAddressOut_WEST[9] destinationAddressOut_WEST[8]
+ destinationAddressOut_WEST[7] destinationAddressOut_WEST[6]
+ destinationAddressOut_WEST[5] destinationAddressOut_WEST[4]
+ destinationAddressOut_WEST[3] destinationAddressOut_WEST[2]
+ destinationAddressOut_WEST[1] destinationAddressOut_WEST[0]
+ requesterAddressOut_WEST[3] requesterAddressOut_WEST[2]
+ requesterAddressOut_WEST[1] requesterAddressOut_WEST[0] readOut_WEST
+ writeOut_WEST dataOut_WEST[5] dataOut_WEST[4] dataOut_WEST[3] dataOut_WEST[2]
+ dataOut_WEST[1] dataOut_WEST[0] outputPortArbiter_1
XwriteInBuffer_SOUTH_reg writeInBuffer_SOUTH clk__L1_N0 N45 DFFQX1TS
XrequesterAddressInBuffer_WEST_reg[3] requesterAddressInBuffer_WEST[3]
+ clk__L1_N0 N91 DFFQX1TS
XrequesterAddressInBuffer_WEST_reg[2] requesterAddressInBuffer_WEST[2]
+ clk__L1_N0 N90 DFFQX1TS
XrequesterAddressInBuffer_WEST_reg[1] requesterAddressInBuffer_WEST[1]
+ clk__L1_N0 N89 DFFQX1TS
XrequesterAddressInBuffer_WEST_reg[0] requesterAddressInBuffer_WEST[0]
+ clk__L1_N0 N88 DFFQX1TS
XwriteInBuffer_NORTH_reg writeInBuffer_NORTH clk__L1_N0 N21 DFFQX1TS
XwriteInBuffer_WEST_reg writeInBuffer_WEST clk__L1_N0 N93 DFFQX1TS
XreadInBuffer_NORTH_reg readInBuffer_NORTH clk__L1_N0 N20 DFFQX1TS
XreadInBuffer_WEST_reg readInBuffer_WEST clk__L1_N0 N92 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[3] destinationAddressInBuffer_SOUTH[3]
+ clk__L1_N0 N31 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[3] destinationAddressInBuffer_EAST[3]
+ clk__L1_N0 N55 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[2] destinationAddressInBuffer_SOUTH[2]
+ clk__L1_N0 N30 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[2] destinationAddressInBuffer_EAST[2]
+ clk__L1_N0 N54 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[1] destinationAddressInBuffer_SOUTH[1]
+ clk__L1_N0 N29 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[1] destinationAddressInBuffer_EAST[1]
+ clk__L1_N0 N53 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[0] destinationAddressInBuffer_SOUTH[0]
+ clk__L1_N0 N28 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[0] destinationAddressInBuffer_EAST[0]
+ clk__L1_N0 N52 DFFQX1TS
XdataInBuffer_SOUTH_reg[5] dataInBuffer_SOUTH[5] clk__L1_N0 N51 DFFQX1TS
XdataInBuffer_EAST_reg[5] dataInBuffer_EAST[5] clk__L1_N0 N75 DFFQX1TS
XdataInBuffer_SOUTH_reg[4] dataInBuffer_SOUTH[4] clk__L1_N0 N50 DFFQX1TS
XdataInBuffer_EAST_reg[4] dataInBuffer_EAST[4] clk__L1_N0 N74 DFFQX1TS
XdataInBuffer_SOUTH_reg[3] dataInBuffer_SOUTH[3] clk__L1_N0 N49 DFFQX1TS
XdataInBuffer_EAST_reg[3] dataInBuffer_EAST[3] clk__L1_N0 N73 DFFQX1TS
XdataInBuffer_SOUTH_reg[2] dataInBuffer_SOUTH[2] clk__L1_N0 N48 DFFQX1TS
XdataInBuffer_EAST_reg[2] dataInBuffer_EAST[2] clk__L1_N0 N72 DFFQX1TS
XdataInBuffer_SOUTH_reg[1] dataInBuffer_SOUTH[1] clk__L1_N0 N47 DFFQX1TS
XdataInBuffer_EAST_reg[1] dataInBuffer_EAST[1] clk__L1_N0 N71 DFFQX1TS
XdataInBuffer_SOUTH_reg[0] dataInBuffer_SOUTH[0] clk__L1_N0 N46 DFFQX1TS
XdataInBuffer_EAST_reg[0] dataInBuffer_EAST[0] clk__L1_N0 N70 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[7] destinationAddressInBuffer_NORTH[7]
+ clk__L1_N0 N11 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[6] destinationAddressInBuffer_NORTH[6]
+ clk__L1_N0 N10 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[5] destinationAddressInBuffer_NORTH[5]
+ clk__L1_N0 N9 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[4] destinationAddressInBuffer_NORTH[4]
+ clk__L1_N0 N8 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[11] destinationAddressInBuffer_WEST[11]
+ clk__L1_N0 N87 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[10] destinationAddressInBuffer_WEST[10]
+ clk__L1_N0 N86 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[9] destinationAddressInBuffer_WEST[9]
+ clk__L1_N0 N85 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[8] destinationAddressInBuffer_WEST[8]
+ clk__L1_N0 N84 DFFQX1TS
XreadInBuffer_EAST_reg readInBuffer_EAST clk__L1_N0 N68 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[11] destinationAddressInBuffer_EAST[11]
+ clk__L1_N0 N63 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[10] destinationAddressInBuffer_EAST[10]
+ clk__L1_N0 N62 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[9] destinationAddressInBuffer_EAST[9]
+ clk__L1_N0 N61 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[8] destinationAddressInBuffer_EAST[8]
+ clk__L1_N0 N60 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[7] destinationAddressInBuffer_SOUTH[7]
+ clk__L1_N0 N35 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[6] destinationAddressInBuffer_SOUTH[6]
+ clk__L1_N0 N34 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[5] destinationAddressInBuffer_SOUTH[5]
+ clk__L1_N0 N33 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[4] destinationAddressInBuffer_SOUTH[4]
+ clk__L1_N0 N32 DFFQX1TS
XwriteInBuffer_EAST_reg writeInBuffer_EAST clk__L1_N0 N69 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[7] destinationAddressInBuffer_EAST[7]
+ clk__L1_N0 N59 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[6] destinationAddressInBuffer_EAST[6]
+ clk__L1_N0 N58 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[5] destinationAddressInBuffer_EAST[5]
+ clk__L1_N0 N57 DFFQX1TS
XdestinationAddressInBuffer_EAST_reg[4] destinationAddressInBuffer_EAST[4]
+ clk__L1_N0 N56 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[11] destinationAddressInBuffer_SOUTH[11]
+ clk__L1_N0 N39 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[10] destinationAddressInBuffer_SOUTH[10]
+ clk__L1_N0 N38 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[9] destinationAddressInBuffer_SOUTH[9]
+ clk__L1_N0 N37 DFFQX1TS
XdestinationAddressInBuffer_SOUTH_reg[8] destinationAddressInBuffer_SOUTH[8]
+ clk__L1_N0 N36 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[11] destinationAddressInBuffer_NORTH[11]
+ clk__L1_N0 N15 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[10] destinationAddressInBuffer_NORTH[10]
+ clk__L1_N0 N14 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[9] destinationAddressInBuffer_NORTH[9]
+ clk__L1_N0 N13 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[8] destinationAddressInBuffer_NORTH[8]
+ clk__L1_N0 N12 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[3] destinationAddressInBuffer_NORTH[3]
+ clk__L1_N0 N7 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[2] destinationAddressInBuffer_NORTH[2]
+ clk__L1_N0 N6 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[1] destinationAddressInBuffer_NORTH[1]
+ clk__L1_N0 N5 DFFQX1TS
XdestinationAddressInBuffer_NORTH_reg[0] destinationAddressInBuffer_NORTH[0]
+ clk__L1_N0 N4 DFFQX1TS
XdataInBuffer_NORTH_reg[5] dataInBuffer_NORTH[5] clk__L1_N0 N27 DFFQX1TS
XdataInBuffer_NORTH_reg[4] dataInBuffer_NORTH[4] clk__L1_N0 N26 DFFQX1TS
XdataInBuffer_NORTH_reg[3] dataInBuffer_NORTH[3] clk__L1_N0 N25 DFFQX1TS
XdataInBuffer_NORTH_reg[2] dataInBuffer_NORTH[2] clk__L1_N0 N24 DFFQX1TS
XdataInBuffer_NORTH_reg[1] dataInBuffer_NORTH[1] clk__L1_N0 N23 DFFQX1TS
XdataInBuffer_NORTH_reg[0] dataInBuffer_NORTH[0] clk__L1_N0 N22 DFFQX1TS
XrequesterAddressInBuffer_SOUTH_reg[3] requesterAddressInBuffer_SOUTH[3]
+ clk__L1_N0 N43 DFFQX1TS
XrequesterAddressInBuffer_SOUTH_reg[2] requesterAddressInBuffer_SOUTH[2]
+ clk__L1_N0 N42 DFFQX1TS
XrequesterAddressInBuffer_SOUTH_reg[1] requesterAddressInBuffer_SOUTH[1]
+ clk__L1_N0 N41 DFFQX1TS
XrequesterAddressInBuffer_SOUTH_reg[0] requesterAddressInBuffer_SOUTH[0]
+ clk__L1_N0 N40 DFFQX1TS
XreadInBuffer_SOUTH_reg readInBuffer_SOUTH clk__L1_N0 N44 DFFQX1TS
XrequesterAddressInBuffer_EAST_reg[3] requesterAddressInBuffer_EAST[3]
+ clk__L1_N0 N67 DFFQX1TS
XrequesterAddressInBuffer_EAST_reg[2] requesterAddressInBuffer_EAST[2]
+ clk__L1_N0 N66 DFFQX1TS
XrequesterAddressInBuffer_EAST_reg[1] requesterAddressInBuffer_EAST[1]
+ clk__L1_N0 N65 DFFQX1TS
XrequesterAddressInBuffer_EAST_reg[0] requesterAddressInBuffer_EAST[0]
+ clk__L1_N0 N64 DFFQX1TS
XdataInBuffer_WEST_reg[5] dataInBuffer_WEST[5] clk__L1_N0 N99 DFFQX1TS
XdataInBuffer_WEST_reg[4] dataInBuffer_WEST[4] clk__L1_N0 N98 DFFQX1TS
XdataInBuffer_WEST_reg[3] dataInBuffer_WEST[3] clk__L1_N0 N97 DFFQX1TS
XdataInBuffer_WEST_reg[2] dataInBuffer_WEST[2] clk__L1_N0 N96 DFFQX1TS
XdataInBuffer_WEST_reg[1] dataInBuffer_WEST[1] clk__L1_N0 N95 DFFQX1TS
XdataInBuffer_WEST_reg[0] dataInBuffer_WEST[0] clk__L1_N0 N94 DFFQX1TS
XrequesterAddressInBuffer_NORTH_reg[3] requesterAddressInBuffer_NORTH[3]
+ clk__L1_N0 N19 DFFQX1TS
XrequesterAddressInBuffer_NORTH_reg[2] requesterAddressInBuffer_NORTH[2]
+ clk__L1_N0 N18 DFFQX1TS
XrequesterAddressInBuffer_NORTH_reg[1] requesterAddressInBuffer_NORTH[1]
+ clk__L1_N0 N17 DFFQX1TS
XrequesterAddressInBuffer_NORTH_reg[0] requesterAddressInBuffer_NORTH[0]
+ clk__L1_N0 N16 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[7] destinationAddressInBuffer_WEST[7]
+ clk__L1_N0 N83 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[6] destinationAddressInBuffer_WEST[6]
+ clk__L1_N0 N82 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[5] destinationAddressInBuffer_WEST[5]
+ clk__L1_N0 N81 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[4] destinationAddressInBuffer_WEST[4]
+ clk__L1_N0 N80 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[3] destinationAddressInBuffer_WEST[3]
+ clk__L1_N0 N79 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[2] destinationAddressInBuffer_WEST[2]
+ clk__L1_N0 N78 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[1] destinationAddressInBuffer_WEST[1]
+ clk__L1_N0 N77 DFFQX1TS
XdestinationAddressInBuffer_WEST_reg[0] destinationAddressInBuffer_WEST[0]
+ clk__L1_N0 N76 DFFQX1TS
XU485 N94 dataIn_WEST[0] FE_PHN231_reset NOR2BX1TS
XU487 N95 dataIn_WEST[1] FE_PHN231_reset NOR2BX1TS
XU488 N96 dataIn_WEST[2] FE_PHN231_reset NOR2BX1TS
XU489 N97 dataIn_WEST[3] FE_PHN231_reset NOR2BX1TS
XU491 N98 dataIn_WEST[4] FE_PHN231_reset NOR2BX1TS
XU492 N99 dataIn_WEST[5] FE_PHN231_reset NOR2BX1TS
XU493 N93 writeIn_WEST FE_PHN231_reset NOR2BX1TS
XU494 N92 readIn_WEST FE_PHN231_reset NOR2BX1TS
XU496 N88 requesterAddressIn_WEST[0] FE_PHN231_reset NOR2BX1TS
XU497 N89 requesterAddressIn_WEST[1] FE_PHN231_reset NOR2BX1TS
XU498 N90 requesterAddressIn_WEST[2] FE_PHN231_reset NOR2BX1TS
XU499 N91 requesterAddressIn_WEST[3] FE_PHN231_reset NOR2BX1TS
XU502 N76 destinationAddressIn_WEST[0] FE_PHN231_reset NOR2BX1TS
XU503 N77 destinationAddressIn_WEST[1] FE_PHN231_reset NOR2BX1TS
XU504 N78 destinationAddressIn_WEST[2] FE_PHN231_reset NOR2BX1TS
XU505 N79 destinationAddressIn_WEST[3] FE_PHN231_reset NOR2BX1TS
XU507 N80 destinationAddressIn_WEST[4] FE_PHN231_reset NOR2BX1TS
XU508 N81 destinationAddressIn_WEST[5] FE_PHN231_reset NOR2BX1TS
XU509 N82 destinationAddressIn_WEST[6] FE_PHN231_reset NOR2BX1TS
XU510 N83 destinationAddressIn_WEST[7] FE_PHN231_reset NOR2BX1TS
XU512 N84 destinationAddressIn_WEST[8] FE_PHN231_reset NOR2BX1TS
XU513 N85 destinationAddressIn_WEST[9] FE_PHN231_reset NOR2BX1TS
XU514 N86 destinationAddressIn_WEST[10] FE_PHN231_reset NOR2BX1TS
XU515 N87 destinationAddressIn_WEST[11] FE_PHN231_reset NOR2BX1TS
XU519 N70 dataIn_EAST[0] FE_PHN231_reset NOR2BX1TS
XU520 N71 dataIn_EAST[1] FE_PHN231_reset NOR2BX1TS
XU521 N72 dataIn_EAST[2] FE_PHN231_reset NOR2BX1TS
XU522 N73 dataIn_EAST[3] FE_PHN231_reset NOR2BX1TS
XU524 N74 dataIn_EAST[4] FE_PHN231_reset NOR2BX1TS
XU525 N75 dataIn_EAST[5] FE_PHN231_reset NOR2BX1TS
XU526 N69 writeIn_EAST FE_PHN231_reset NOR2BX1TS
XU527 N68 readIn_EAST FE_PHN231_reset NOR2BX1TS
XU529 N64 requesterAddressIn_EAST[0] FE_PHN231_reset NOR2BX1TS
XU530 N65 requesterAddressIn_EAST[1] FE_PHN231_reset NOR2BX1TS
XU531 N66 requesterAddressIn_EAST[2] FE_PHN231_reset NOR2BX1TS
XU532 N67 requesterAddressIn_EAST[3] FE_PHN231_reset NOR2BX1TS
XU535 N52 destinationAddressIn_EAST[0] FE_PHN231_reset NOR2BX1TS
XU536 N53 destinationAddressIn_EAST[1] FE_PHN231_reset NOR2BX1TS
XU537 N54 destinationAddressIn_EAST[2] FE_PHN231_reset NOR2BX1TS
XU538 N55 destinationAddressIn_EAST[3] FE_PHN231_reset NOR2BX1TS
XU540 N56 destinationAddressIn_EAST[4] FE_PHN231_reset NOR2BX1TS
XU541 N57 destinationAddressIn_EAST[5] FE_PHN231_reset NOR2BX1TS
XU542 N58 destinationAddressIn_EAST[6] FE_PHN231_reset NOR2BX1TS
XU543 N59 destinationAddressIn_EAST[7] FE_PHN231_reset NOR2BX1TS
XU545 N60 destinationAddressIn_EAST[8] FE_PHN231_reset NOR2BX1TS
XU546 N61 destinationAddressIn_EAST[9] FE_PHN231_reset NOR2BX1TS
XU547 N62 destinationAddressIn_EAST[10] FE_PHN231_reset NOR2BX1TS
XU548 N63 destinationAddressIn_EAST[11] FE_PHN231_reset NOR2BX1TS
XU550 N46 dataIn_SOUTH[0] FE_PHN231_reset NOR2BX1TS
XU551 N47 dataIn_SOUTH[1] FE_PHN231_reset NOR2BX1TS
XU552 N48 dataIn_SOUTH[2] FE_PHN231_reset NOR2BX1TS
XU554 N49 dataIn_SOUTH[3] FE_PHN231_reset NOR2BX1TS
XU555 N50 dataIn_SOUTH[4] FE_PHN231_reset NOR2BX1TS
XU556 N51 dataIn_SOUTH[5] FE_PHN231_reset NOR2BX1TS
XU557 N45 writeIn_SOUTH FE_PHN231_reset NOR2BX1TS
XU559 N44 readIn_SOUTH FE_PHN231_reset NOR2BX1TS
XU560 N40 requesterAddressIn_SOUTH[0] FE_PHN231_reset NOR2BX1TS
XU561 N41 requesterAddressIn_SOUTH[1] FE_PHN231_reset NOR2BX1TS
XU562 N42 requesterAddressIn_SOUTH[2] FE_PHN231_reset NOR2BX1TS
XU565 N43 requesterAddressIn_SOUTH[3] FE_PHN231_reset NOR2BX1TS
XU566 N28 destinationAddressIn_SOUTH[0] FE_PHN231_reset NOR2BX1TS
XU567 N29 destinationAddressIn_SOUTH[1] FE_PHN231_reset NOR2BX1TS
XU568 N30 destinationAddressIn_SOUTH[2] FE_PHN231_reset NOR2BX1TS
XU570 N31 destinationAddressIn_SOUTH[3] FE_PHN231_reset NOR2BX1TS
XU571 N32 destinationAddressIn_SOUTH[4] FE_PHN231_reset NOR2BX1TS
XU572 N33 destinationAddressIn_SOUTH[5] FE_PHN231_reset NOR2BX1TS
XU573 N34 destinationAddressIn_SOUTH[6] FE_PHN231_reset NOR2BX1TS
XU575 N35 destinationAddressIn_SOUTH[7] FE_PHN231_reset NOR2BX1TS
XU576 N36 destinationAddressIn_SOUTH[8] FE_PHN231_reset NOR2BX1TS
XU577 N37 destinationAddressIn_SOUTH[9] FE_PHN231_reset NOR2BX1TS
XU578 N38 destinationAddressIn_SOUTH[10] FE_PHN231_reset NOR2BX1TS
XU581 N39 destinationAddressIn_SOUTH[11] FE_PHN231_reset NOR2BX1TS
XU582 N22 dataIn_NORTH[0] FE_PHN231_reset NOR2BX1TS
XU583 N23 dataIn_NORTH[1] FE_PHN231_reset NOR2BX1TS
XU584 N24 dataIn_NORTH[2] FE_PHN231_reset NOR2BX1TS
XU586 N25 dataIn_NORTH[3] FE_PHN231_reset NOR2BX1TS
XU587 N26 dataIn_NORTH[4] FE_PHN231_reset NOR2BX1TS
XU588 N27 dataIn_NORTH[5] FE_PHN231_reset NOR2BX1TS
XU589 N21 writeIn_NORTH FE_PHN231_reset NOR2BX1TS
XU591 N20 readIn_NORTH FE_PHN231_reset NOR2BX1TS
XU592 N16 requesterAddressIn_NORTH[0] FE_PHN231_reset NOR2BX1TS
XU593 N17 requesterAddressIn_NORTH[1] FE_PHN231_reset NOR2BX1TS
XU594 N18 requesterAddressIn_NORTH[2] FE_PHN231_reset NOR2BX1TS
XU596 N19 requesterAddressIn_NORTH[3] FE_PHN231_reset NOR2BX1TS
XU597 N4 destinationAddressIn_NORTH[0] FE_PHN231_reset NOR2BX1TS
XU598 N5 destinationAddressIn_NORTH[1] FE_PHN231_reset NOR2BX1TS
XU599 N6 destinationAddressIn_NORTH[2] FE_PHN231_reset NOR2BX1TS
XU601 N7 destinationAddressIn_NORTH[3] FE_PHN231_reset NOR2BX1TS
XU602 N8 destinationAddressIn_NORTH[4] FE_PHN231_reset NOR2BX1TS
XU603 N9 destinationAddressIn_NORTH[5] FE_PHN231_reset NOR2BX1TS
XU604 N10 destinationAddressIn_NORTH[6] FE_PHN231_reset NOR2BX1TS
XU606 N11 destinationAddressIn_NORTH[7] FE_PHN231_reset NOR2BX1TS
XU607 N12 destinationAddressIn_NORTH[8] FE_PHN231_reset NOR2BX1TS
XU608 N13 destinationAddressIn_NORTH[9] FE_PHN231_reset NOR2BX1TS
XU609 N14 destinationAddressIn_NORTH[10] FE_PHN231_reset NOR2BX1TS
XU610 N15 destinationAddressIn_NORTH[11] FE_PHN231_reset NOR2BX1TS
.ENDS
.GLOBAL VDD
.GLOBAL VSS
